options:
  parameters:
    id: lab10_dvbt2_analyze
    title: Lab 10c - DVB-T2 Receiver-Side Analyzer
    author: SignalSDR Pro Lab
    description: 'Measure a DVB-T2 signal: spectrum, cyclic-prefix timing, amplitude statistics'
    generate_options: qt_gui
  states: {}

blocks:
- name: note_what
  id: note
  parameters:
    note: Receiver-side ANALYSIS. GNU Radio has no DVB-T2 demodulator - a real TV or USB tuner does the decoding. This measures the signal.
    comment: What this flowgraph is and is not.
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (8000000.0 * 8) / 7
    comment: 'Must match the transmitter: 64/7 = 9.142857 MSPS.'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '32768'
    comment: Useful OFDM symbol length - 32K, the mode Lab 10 transmits (FFTSIZE_32K_T2GI). The cyclic-prefix correlator below uses this as its delay. For a 1K test signal, set 1024.
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: fft_len // 128
    comment: Guard interval length - GI 1/128, as transmitted, so 256 samples. The correlator averages over exactly this many samples. For GI 1/8 use fft_len // 8.
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 474e6
    comment: Only used to label the spectrum axis, and by the USRP source if you enable it.
  states: {}
- name: iq_file
  id: variable
  parameters:
    value: '''/tmp/dvbt2_signal_9M14_fc32.iq'''
    comment: Made by lab10_dvbt2_generate.grc, or recorded off the air with Lab 05.
  states: {}
- name: file_source
  id: blocks_file_source
  parameters:
    file: iq_file
    type: complex
    repeat: 'True'
    comment: 'Default input: analyse a generated or recorded file, with no hardware at all.'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: samp_rate
    comment: MANDATORY with a File Source - see Lab 05.
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    type: fc32
    dev_addr: ''''''
    dev_args: ''''''
    samp_rate: samp_rate
    sync: none
    ant0: '''RX2'''
    bw0: samp_rate
    center_freq0: center_freq
    gain0: '30'
    comment: THE SECOND SDR. Disabled by default. Enable this and disable file_source+throttle to analyse a live transmission.
  states: {state: disabled}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '''DVB-T2 spectrum - a flat-topped 7.8 MHz block, not a hump'''
    fftsize: '4096'
    fc: center_freq
    bw: samp_rate
    ymin: '-120'
    ymax: '0'
    average: '0.2'
    grid: 'True'
    gui_hint: 0,0,1,1
    comment: The flat top IS the 27,841 OFDM carriers (32K extended mode). Steep skirts are the sign of a well-formed OFDM signal.
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: '''Waterfall'''
    fftsize: '2048'
    fc: center_freq
    bw: samp_rate
    gui_hint: 0,1,1,1
    comment: A continuous transmission looks like a solid band. Watch the T2 frame boundaries if you look closely.
  states: {}
- name: delay_fft
  id: blocks_delay
  parameters:
    type: complex
    delay: fft_len
    comment: 'CYCLIC PREFIX DETECTOR, part 1: delay by exactly one useful symbol length.'
  states: {}
- name: conj
  id: blocks_conjugate_cc
  parameters:
    comment: 'Part 2: conjugate the delayed copy.'
  states: {}
- name: correlate
  id: blocks_multiply_xx
  parameters:
    type: complex
    comment: 'Part 3: x[n] * conj(x[n-32768]). Inside the guard interval these are the SAME samples, so the product is a positive real number.'
  states: {}
- name: integrate
  id: blocks_moving_average_xx
  parameters:
    type: complex
    length: cp_len
    scale: 1.0/cp_len
    max_iter: '4096'
    comment: 'Part 4: average over the guard length. This is the classic van de Beek OFDM timing estimator.'
  states: {}
- name: corr_mag
  id: blocks_complex_to_mag
  parameters:
    comment: 'Part 5: magnitude. Peaks mark the start of every OFDM symbol.'
  states: {}
- name: corr_plot
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '''Cyclic-prefix correlation - one peak per OFDM symbol (every 33,024 samples = 3.6 ms)'''
    ylabel: Correlation
    size: '132096'
    srate: samp_rate
    ymin: '0'
    ymax: '0.2'
    grid: 'True'
    autoscale: 'True'
    gui_hint: 1,0,1,2
    comment: THE MONEY SHOT. 132,096 samples spans 4 symbols of 33,024, so you should see 4 evenly spaced peaks.
  states: {}
- name: mag
  id: blocks_complex_to_mag
  parameters:
    comment: Envelope, for the amplitude histogram.
  states: {}
- name: hist
  id: qtgui_histogram_sink_x
  parameters:
    type: float
    name: '''Amplitude distribution - Rayleigh, because OFDM is Gaussian'''
    size: '2048'
    bins: '100'
    grid: 'True'
    xmin: '0'
    xmax: '1'
    gui_hint: 2,0,1,2
    comment: A sum of ~28,000 random carriers is Gaussian, so |x| is Rayleigh. The long tail is the PAPR problem, visible.
  states: {}

connections:
- [file_source, '0', throttle, '0']
- [throttle, '0', spectrum, '0']
- [throttle, '0', waterfall, '0']
- [throttle, '0', delay_fft, '0']
- [throttle, '0', correlate, '0']
- [delay_fft, '0', conj, '0']
- [conj, '0', correlate, '1']
- [correlate, '0', integrate, '0']
- [integrate, '0', corr_mag, '0']
- [corr_mag, '0', corr_plot, '0']
- [throttle, '0', mag, '0']
- [mag, '0', hist, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
