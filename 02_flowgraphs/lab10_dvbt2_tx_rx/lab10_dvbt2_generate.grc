options:
  parameters:
    id: lab10_dvbt2_generate
    title: Lab 10a - DVB-T2 Signal Generator (to file, no RF)
    author: SignalSDR Pro Lab
    description: Build a standards-compliant DVB-T2 waveform and write it to disk for analysis
    generate_options: qt_gui
  states: {}

blocks:
- name: note_legal
  id: note
  parameters:
    note: THIS TRANSMITS. Faraday cage, or cable + attenuator into a dummy load. Never into an antenna.
    comment: Read the README before running the RF version of this lab.
  states: {}
- name: note_cfg
  id: note
  parameters:
    note: |-
      Config = official gr-dtv profile vv003-cr23: 32K extended, 256QAM, CR 2/3, GI 1/128, PP7
      -> 40.000738 Mbit/s. This is the mode UK Freeview HD and Malaysian MYTV broadcast.
      To change it you must edit TEN blocks together - see README.
    comment: DVB-T2 parameters are GRC enums, so they cannot be driven from one variable.
  states: {}
- name: note_video
  id: note
  parameters:
    note: |-
      VIDEO: make the stream first, at EXACTLY this mode's rate --
        03_scripts/make_video_ts.py ~/Downloads/Bintang.mp4 /tmp/bintang_dvbt2.ts \
            --standard dvbt2 --t2-fft 32k --t2-guard 1/128 --t2-rate 2/3 \
            --t2-fecblocks 202 --t2-datasyms 59 --video-bitrate 12000000
      No ffmpeg? 03_scripts/make_test_ts.py --rate 40000738 gives a valid, pictureless mux.
    comment: A real television will list the service by the name in the SDT.
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (8000000.0 * 8) / 7
    comment: 'The DVB-T2 elementary rate for an 8 MHz channel: 64/7 = 9.142857 MSPS. Not negotiable - it defines the OFDM carrier spacing.'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '32768'
    comment: FFT size. 32K is what real broadcasters use - UK Freeview HD and Malaysian MYTV both run 32K. Must match FFTSIZE_32K_T2GI in the five blocks that take it.
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: fft_len // 128
    comment: 'Guard interval 1/128 = 256 samples = 28 us. Short, because a 32K symbol is already 3.58 ms long: the guard is a fraction of the symbol, and 28 us still covers 8.4 km of echo.'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '59'
    comment: Data symbols per T2 frame. With 1 P2 symbol that makes a frame of 2048 + 60 x 33024 = 1,983,488 samples = 216.9 ms.
  states: {}
- name: fec_blocks
  id: variable
  parameters:
    value: '202'
    comment: 'LDPC blocks per T2 frame. This is what sets the payload rate: 202 x (43040 - 80) bits per 216.9 ms = 40.000738 Mbit/s.'
  states: {}
- name: ti_blocks
  id: variable
  parameters:
    value: '3'
    comment: Time-interleaver blocks per frame.
  states: {}
- name: ts_file
  id: variable
  parameters:
    value: '''/tmp/bintang_dvbt2.ts'''
    comment: Transport stream, which MUST be muxed at exactly 40,000,738 bit/s. make_video_ts.py computes that from the modulation and --verify checks it against the PCR.
  states: {}
- name: ts_source
  id: blocks_file_source
  parameters:
    file: ts_file
    type: byte
    repeat: 'True'
    comment: repeat=True means the PHYSICAL layer never runs dry - only the TS content loops.
  states: {}
- name: bbheader
  id: dtv_dvb_bbheader_bb
  parameters:
    standard: STANDARD_DVBT2
    framesize1: FECFRAME_NORMAL
    rate1: C2_3
    mode: INPUTMODE_NORMAL
    inband: INBAND_OFF
    comment: STAGE 1 - Baseband framing. Slices the TS into BBFRAMEs and prepends a header saying how they are coded.
  states: {}
- name: bbscrambler
  id: dtv_dvb_bbscrambler_bb
  parameters:
    standard: STANDARD_DVBT2
    framesize1: FECFRAME_NORMAL
    rate1: C2_3
    comment: STAGE 2 - Energy dispersal. XOR with a PRBS so a run of identical bytes does not produce a line spectrum.
  states: {}
- name: bch
  id: dtv_dvb_bch_bb
  parameters:
    standard: STANDARD_DVBT2
    framesize1: FECFRAME_NORMAL
    rate1: C2_3
    comment: STAGE 3 - BCH outer code. Mops up the residual errors the LDPC decoder leaves behind (its error floor).
  states: {}
- name: ldpc
  id: dtv_dvb_ldpc_bb
  parameters:
    standard: STANDARD_DVBT2
    framesize1: FECFRAME_NORMAL
    rate1: C2_3
    comment: STAGE 4 - LDPC inner code, 64800-bit codewords. This is what gets DVB-T2 within ~1 dB of the Shannon limit.
  states: {}
- name: bitinterleaver
  id: dtv_dvbt2_interleaver_bb
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C2_3
    constellation: MOD_256QAM
    comment: STAGE 5 - Bit interleaver. Spreads each LDPC codeword across constellation bits of differing reliability.
  states: {}
- name: modulator
  id: dtv_dvbt2_modulator_bc
  parameters:
    framesize: FECFRAME_NORMAL
    constellation: MOD_256QAM
    rotation: ROTATION_ON
    comment: STAGE 6 - Map bits to constellation points. ROTATION_ON rotates the constellation so I and Q each carry full information.
  states: {}
- name: cellinterleaver
  id: dtv_dvbt2_cellinterleaver_cc
  parameters:
    framesize: FECFRAME_NORMAL
    constellation: MOD_256QAM
    fecblocks: fec_blocks
    tiblocks: ti_blocks
    comment: STAGE 7 - Cell and TIME interleaving. Spreads one codeword over hundreds of ms so a burst of noise cannot kill it.
  states: {}
- name: framemapper
  id: dtv_dvbt2_framemapper_cc
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C2_3
    constellation: MOD_256QAM
    rotation: ROTATION_ON
    fecblocks: fec_blocks
    tiblocks: ti_blocks
    carriermode: CARRIERS_EXTENDED
    fftsize1: FFTSIZE_32K_T2GI
    guardinterval: GI_1_128
    l1constellation: L1_MOD_64QAM
    pilotpattern: PILOT_PP7
    t2frames: '2'
    numdatasyms: num_data_syms
    paprmode1: PAPR_OFF
    version: VERSION_111
    preamble1: PREAMBLE_T2_SISO
    comment: STAGE 8 - Build the T2 frame and the P2 symbols carrying L1 signalling, which tells the receiver how everything above was configured.
  states: {}
- name: freqinterleaver
  id: dtv_dvbt2_freqinterleaver_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize: FFTSIZE_32K_T2GI
    pilotpattern: PILOT_PP7
    guardinterval: GI_1_128
    numdatasyms: num_data_syms
    paprmode1: PAPR_OFF
    version: VERSION_111
    preamble1: PREAMBLE_T2_SISO
    comment: STAGE 9 - Frequency interleaver. Scatters cells across OFDM carriers so a notch in the channel does not wipe out consecutive data.
  states: {}
- name: pilotgenerator
  id: dtv_dvbt2_pilotgenerator_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize: FFTSIZE_32K_T2GI
    pilotpattern: PILOT_PP7
    guardinterval: GI_1_128
    numdatasyms: num_data_syms
    paprmode1: PAPR_OFF
    version: VERSION_111
    preamble1: PREAMBLE_T2_SISO
    equalization: EQUALIZATION_OFF
    bandwidth: BANDWIDTH_8_0_MHZ
    comment: STAGE 10 - Insert scattered/continual pilots, then IFFT. Output is a time-domain OFDM symbol. The pilots are what the receiver equalises against.
  states: {}
- name: cyclic_prefixer
  id: digital_ofdm_cyclic_prefixer
  parameters:
    input_size: fft_len
    cp_len: cp_len
    tagname: '""'
    comment: STAGE 11 - Copy the last 1/8 of each symbol to its front. This is what makes OFDM immune to multipath up to the guard length.
  states: {}
- name: p1insertion
  id: dtv_dvbt2_p1insertion_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize1: FFTSIZE_32K_T2GI
    guardinterval: GI_1_128
    numdatasyms: num_data_syms
    preamble1: PREAMBLE_T2_SISO
    showlevels: SHOWLEVELS_OFF
    version: VERSION_111
    comment: STAGE 12 - Prepend the P1 preamble symbol. A receiver finds this FIRST, by correlation, before it knows anything else.
  states: {}
- name: tx_scale
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: tx_amplitude
    comment: Digital backoff. OFDM has a high peak-to-average ratio (~10 dB), so keep the average well below full scale or the peaks clip.
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '''DVB-T2 signal - should be a 7.6 MHz flat-topped block'''
    fftsize: '4096'
    fc: '0'
    bw: samp_rate
    ymin: '-120'
    ymax: '0'
    average: '0.2'
    grid: 'True'
    gui_hint: 0,0,1,1
    comment: OFDM looks like a rectangle, not a hump. The flat top IS the thousand-odd carriers.
  states: {}
- name: timeplot
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: '''Time domain - noise-like, with high peaks'''
    size: '2048'
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    gui_hint: 0,1,1,1
    comment: A sum of ~1000 independent carriers is Gaussian by the central limit theorem. That is why the PAPR is so high.
  states: {}
- name: tx_amplitude
  id: variable
  parameters:
    value: '0.25'
    comment: Fixed here because nothing is being transmitted - only written to disk.
  states: {}
- name: iq_file
  id: variable
  parameters:
    value: '''/tmp/dvbt2_signal_9M14_fc32.iq'''
    comment: Output IQ. Feed this to lab10_dvbt2_analyze.grc and to 03_scripts/analyze_dvbt2.py.
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    value: '3.0'
    comment: How much signal to generate. 3 s at 9.14 MSPS is 220 MB.
  states: {}
- name: head
  id: blocks_head
  parameters:
    type: complex
    num_items: int(samp_rate * capture_seconds)
    comment: Bounds the output. Without hardware to pace it, this flowgraph would otherwise fill your disk.
  states: {}
- name: iq_sink
  id: blocks_file_sink
  parameters:
    file: iq_file
    type: complex
    comment: Raw interleaved float32 IQ, same format as Lab 05.
  states: {}

connections:
- [ts_source, '0', bbheader, '0']
- [bbheader, '0', bbscrambler, '0']
- [bbscrambler, '0', bch, '0']
- [bch, '0', ldpc, '0']
- [ldpc, '0', bitinterleaver, '0']
- [bitinterleaver, '0', modulator, '0']
- [modulator, '0', cellinterleaver, '0']
- [cellinterleaver, '0', framemapper, '0']
- [framemapper, '0', freqinterleaver, '0']
- [freqinterleaver, '0', pilotgenerator, '0']
- [pilotgenerator, '0', cyclic_prefixer, '0']
- [cyclic_prefixer, '0', p1insertion, '0']
- [p1insertion, '0', tx_scale, '0']
- [tx_scale, '0', spectrum, '0']
- [tx_scale, '0', timeplot, '0']
- [tx_scale, '0', head, '0']
- [head, '0', iq_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
