options:
  parameters:
    id: lab10_dvbt2_tx
    title: Lab 10b - DVB-T2 Transmitter (RF - Faraday cage or dummy load ONLY)
    author: SignalSDR Pro Lab
    description: Transmit a standards-compliant DVB-T2 multiplex for a real TV or tuner to receive
    generate_options: qt_gui
  states: {}

blocks:
- name: note_legal
  id: note
  parameters:
    note: THIS TRANSMITS. Faraday cage, or cable + attenuator into a dummy load. Never into an antenna.
    comment: Read the README before running the RF version of this lab.
  states: {}
- name: note_cfg
  id: note
  parameters:
    note: |-
      Config = official gr-dtv profile vv003-cr23: 32K extended, 256QAM, CR 2/3, GI 1/128, PP7
      -> 40.000738 Mbit/s. This is the mode UK Freeview HD and Malaysian MYTV broadcast.
      To change it you must edit TEN blocks together - see README.
    comment: DVB-T2 parameters are GRC enums, so they cannot be driven from one variable.
  states: {}
- name: note_video
  id: note
  parameters:
    note: |-
      PLAYOUT FIRST, then start this flowgraph:
        03_scripts/tv_playout.py ~/Downloads/Bintang.mp4 --standard dvbt2 --t2-fft 32k \
            --t2-guard 1/128 --t2-rate 2/3 --t2-fecblocks 202 --t2-datasyms 59 \
            --video-bitrate 12000000 --fifo /tmp/tv.fifo
      Do NOT point ts_file at a finished .ts with repeat=True: at every lap the PCR jumps
      BACKWARD by the file's whole length and the picture goes sluggish. Measured: -208.86 s.
    comment: A real television will list the service by the name in the SDT.
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (8000000.0 * 8) / 7
    comment: 'The DVB-T2 elementary rate for an 8 MHz channel: 64/7 = 9.142857 MSPS. Not negotiable - it defines the OFDM carrier spacing.'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '32768'
    comment: FFT size. 32K is what real broadcasters use - UK Freeview HD and Malaysian MYTV both run 32K. Must match FFTSIZE_32K_T2GI in the five blocks that take it.
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: fft_len // 128
    comment: 'Guard interval 1/128 = 256 samples = 28 us. Short, because a 32K symbol is already 3.58 ms long: the guard is a fraction of the symbol, and 28 us still covers 8.4 km of echo.'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '59'
    comment: Data symbols per T2 frame. With 1 P2 symbol that makes a frame of 2048 + 60 x 33024 = 1,983,488 samples = 216.9 ms.
  states: {}
- name: fec_blocks
  id: variable
  parameters:
    value: '202'
    comment: 'LDPC blocks per T2 frame. This is what sets the payload rate: 202 x (43040 - 80) bits per 216.9 ms = 40.000738 Mbit/s.'
  states: {}
- name: ti_blocks
  id: variable
  parameters:
    value: '3'
    comment: Time-interleaver blocks per frame.
  states: {}
- name: ts_file
  id: variable
  parameters:
    value: '''/tmp/tv.fifo'''
    comment: A named pipe fed by 03_scripts/tv_playout.py, not a file. Playout loops the VIDEO inside ffmpeg so the transport stream clock counts upwards forever. Looping a finished .ts instead sends the PCR backwards every lap, which a television shows as permanently sluggish playback.
  states: {}
- name: ts_source
  id: blocks_file_source
  parameters:
    file: ts_file
    type: byte
    repeat: 'False'
    comment: 'Reads the playout FIFO. repeat=False on purpose: a FIFO never reaches EOF while the writer lives, and if playout dies you want this to stop rather than spin on a rewind that cannot happen.'
  states: {}
- name: bbheader
  id: dtv_dvb_bbheader_bb
  parameters:
    standard: STANDARD_DVBT2
    framesize1: FECFRAME_NORMAL
    rate1: C2_3
    mode: INPUTMODE_NORMAL
    inband: INBAND_OFF
    comment: STAGE 1 - Baseband framing. Slices the TS into BBFRAMEs and prepends a header saying how they are coded.
  states: {}
- name: bbscrambler
  id: dtv_dvb_bbscrambler_bb
  parameters:
    standard: STANDARD_DVBT2
    framesize1: FECFRAME_NORMAL
    rate1: C2_3
    comment: STAGE 2 - Energy dispersal. XOR with a PRBS so a run of identical bytes does not produce a line spectrum.
  states: {}
- name: bch
  id: dtv_dvb_bch_bb
  parameters:
    standard: STANDARD_DVBT2
    framesize1: FECFRAME_NORMAL
    rate1: C2_3
    comment: STAGE 3 - BCH outer code. Mops up the residual errors the LDPC decoder leaves behind (its error floor).
  states: {}
- name: ldpc
  id: dtv_dvb_ldpc_bb
  parameters:
    standard: STANDARD_DVBT2
    framesize1: FECFRAME_NORMAL
    rate1: C2_3
    comment: STAGE 4 - LDPC inner code, 64800-bit codewords. This is what gets DVB-T2 within ~1 dB of the Shannon limit.
  states: {}
- name: bitinterleaver
  id: dtv_dvbt2_interleaver_bb
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C2_3
    constellation: MOD_256QAM
    comment: STAGE 5 - Bit interleaver. Spreads each LDPC codeword across constellation bits of differing reliability.
  states: {}
- name: modulator
  id: dtv_dvbt2_modulator_bc
  parameters:
    framesize: FECFRAME_NORMAL
    constellation: MOD_256QAM
    rotation: ROTATION_ON
    comment: STAGE 6 - Map bits to constellation points. ROTATION_ON rotates the constellation so I and Q each carry full information.
  states: {}
- name: cellinterleaver
  id: dtv_dvbt2_cellinterleaver_cc
  parameters:
    framesize: FECFRAME_NORMAL
    constellation: MOD_256QAM
    fecblocks: fec_blocks
    tiblocks: ti_blocks
    comment: STAGE 7 - Cell and TIME interleaving. Spreads one codeword over hundreds of ms so a burst of noise cannot kill it.
  states: {}
- name: framemapper
  id: dtv_dvbt2_framemapper_cc
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C2_3
    constellation: MOD_256QAM
    rotation: ROTATION_ON
    fecblocks: fec_blocks
    tiblocks: ti_blocks
    carriermode: CARRIERS_EXTENDED
    fftsize1: FFTSIZE_32K_T2GI
    guardinterval: GI_1_128
    l1constellation: L1_MOD_64QAM
    pilotpattern: PILOT_PP7
    t2frames: '2'
    numdatasyms: num_data_syms
    paprmode1: PAPR_OFF
    version: VERSION_111
    preamble1: PREAMBLE_T2_SISO
    comment: STAGE 8 - Build the T2 frame and the P2 symbols carrying L1 signalling, which tells the receiver how everything above was configured.
  states: {}
- name: freqinterleaver
  id: dtv_dvbt2_freqinterleaver_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize: FFTSIZE_32K_T2GI
    pilotpattern: PILOT_PP7
    guardinterval: GI_1_128
    numdatasyms: num_data_syms
    paprmode1: PAPR_OFF
    version: VERSION_111
    preamble1: PREAMBLE_T2_SISO
    comment: STAGE 9 - Frequency interleaver. Scatters cells across OFDM carriers so a notch in the channel does not wipe out consecutive data.
  states: {}
- name: pilotgenerator
  id: dtv_dvbt2_pilotgenerator_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize: FFTSIZE_32K_T2GI
    pilotpattern: PILOT_PP7
    guardinterval: GI_1_128
    numdatasyms: num_data_syms
    paprmode1: PAPR_OFF
    version: VERSION_111
    preamble1: PREAMBLE_T2_SISO
    equalization: EQUALIZATION_OFF
    bandwidth: BANDWIDTH_8_0_MHZ
    comment: STAGE 10 - Insert scattered/continual pilots, then IFFT. Output is a time-domain OFDM symbol. The pilots are what the receiver equalises against.
  states: {}
- name: cyclic_prefixer
  id: digital_ofdm_cyclic_prefixer
  parameters:
    input_size: fft_len
    cp_len: cp_len
    tagname: '""'
    comment: STAGE 11 - Copy the last 1/8 of each symbol to its front. This is what makes OFDM immune to multipath up to the guard length.
  states: {}
- name: p1insertion
  id: dtv_dvbt2_p1insertion_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize1: FFTSIZE_32K_T2GI
    guardinterval: GI_1_128
    numdatasyms: num_data_syms
    preamble1: PREAMBLE_T2_SISO
    showlevels: SHOWLEVELS_OFF
    version: VERSION_111
    comment: STAGE 12 - Prepend the P1 preamble symbol. A receiver finds this FIRST, by correlation, before it knows anything else.
  states: {}
- name: tx_scale
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: tx_amplitude
    comment: 'Amplitude control AND the smoothing reservoir: minoutbuf holds 4,194,304 complex samples (about 0.46 s), which is two T2 frames. This is what turns a bursty producer into a continuous transmission.'
    minoutbuf: '4194304'
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '''DVB-T2 signal - should be a 7.6 MHz flat-topped block'''
    fftsize: '4096'
    fc: '0'
    bw: samp_rate
    ymin: '-120'
    ymax: '0'
    average: '0.2'
    grid: 'True'
    gui_hint: 0,0,1,1
    comment: OFDM looks like a rectangle, not a hump. The flat top IS the thousand-odd carriers.
  states: {}
- name: timeplot
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: '''Time domain - noise-like, with high peaks'''
    size: '2048'
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    gui_hint: 0,1,1,1
    comment: A sum of ~1000 independent carriers is Gaussian by the central limit theorem. That is why the PAPR is so high.
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 474e6
    comment: UHF channel 21. PICK A CHANNEL THAT IS EMPTY WHERE YOU ARE, and only radiate inside a Faraday cage.
  states: {}
- name: tx_amplitude
  id: variable_qtgui_range
  parameters:
    label: '''TX digital amplitude'''
    start: '0.0'
    stop: '0.5'
    step: '0.01'
    value: '0.0'
    min_len: '300'
    comment: STARTS AT ZERO ON PURPOSE. Raise it deliberately once you have checked what is connected to the antenna port.
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: '''TX RF gain (dB)'''
    start: '0'
    stop: '89'
    step: '1'
    value: '0'
    min_len: '300'
    comment: Also starts at zero. In a cage or on a cable you need almost none of this.
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    type: fc32
    dev_addr: '"send_frame_size=8192,num_send_frames=1024"'
    dev_args: ''''''
    samp_rate: samp_rate
    sync: none
    ant0: '''TX/RX'''
    bw0: samp_rate
    center_freq0: center_freq
    gain0: tx_gain
    comment: 'Transmit. The large send buffer matters here: the framemapper and cell interleaver work on WHOLE T2 frames, so the chain delivers 1,983,488 samples in a burst every 216.9 ms rather than a steady trickle. Without a reservoir the DAC runs dry in the gap and you get underflows even though the chain averages 7.8x real time.'
  states: {}

connections:
- [ts_source, '0', bbheader, '0']
- [bbheader, '0', bbscrambler, '0']
- [bbscrambler, '0', bch, '0']
- [bch, '0', ldpc, '0']
- [ldpc, '0', bitinterleaver, '0']
- [bitinterleaver, '0', modulator, '0']
- [modulator, '0', cellinterleaver, '0']
- [cellinterleaver, '0', framemapper, '0']
- [framemapper, '0', freqinterleaver, '0']
- [freqinterleaver, '0', pilotgenerator, '0']
- [pilotgenerator, '0', cyclic_prefixer, '0']
- [cyclic_prefixer, '0', p1insertion, '0']
- [p1insertion, '0', tx_scale, '0']
- [tx_scale, '0', spectrum, '0']
- [tx_scale, '0', timeplot, '0']
- [tx_scale, '0', usrp_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
