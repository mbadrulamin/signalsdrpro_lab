options:
  parameters:
    id: lab02_enhanced_wbfm
    title: Lab 02 - Enhanced WBFM with Visualization (SignalSDR Pro)
    author: SignalSDR Pro Lab
    description: FM receiver with spectrum, waterfall, time displays and 48 kHz audio
    generate_options: qt_gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: USRP sample rate (2 MSPS for wider view)
    value: '2000000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: Target audio sample rate
    value: '48000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    comment: audio_rate * audio_decimation
    value: '384000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: FM Station (Hz)
    start: 87.5e6
    stop: 108e6
    step: 100e3
    value: 100.0e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (dB)
    start: '0'
    stop: '76'
    step: '1'
    value: '40'
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    type: fc32
    samp_rate: samp_rate
    sync: none
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: gain
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Spectrum"'
    fftsize: '2048'
    fc: freq
    bw: samp_rate
    average: '0.5'
    label1: '"Raw IQ"'
  states: {}
- name: waterfall_sink
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: '"Waterfall"'
    fftsize: '2048'
    fc: freq
    bw: samp_rate
    intensity_range: '[-140, 0]'
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: '"IQ Time Domain"'
    size: '1024'
    srate: samp_rate
    autoscale: 'True'
    label1: '"I (real)"'
    label2: '"Q (imag)"'
  states: {}
- name: rational_resampler
  id: rational_resampler_xxx
  parameters:
    type: ccc
    interp: '24'
    decim: '125'
  states: {}
- name: wbfm_rcv
  id: analog_wfm_rcv
  parameters:
    quad_rate: quad_rate
    audio_decimation: '8'
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: audio_rate
    device_name: '""'
  states: {}

connections:
- [usrp_source, '0', freq_sink, '0']
- [usrp_source, '0', waterfall_sink, '0']
- [usrp_source, '0', time_sink, '0']
- [usrp_source, '0', rational_resampler, '0']
- [rational_resampler, '0', wbfm_rcv, '0']
- [wbfm_rcv, '0', audio_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
