options:
  parameters:
    id: lab11_tv_receiver
    title: Lab 11 - DVB-T Television Receiver
    author: SignalSDR Pro Lab
    description: Receive a DVB-T channel, measure its quality, and watch the picture
    generate_options: qt_gui
    output_language: python
  states: {}

blocks:
- name: note_what
  id: note
  parameters:
    note: DVB-T television receiver. Demodulates an 8 MHz terrestrial TV channel all the way to MPEG-2 transport stream, and hands it to ffplay for a live picture.
    comment: Start here. Read the README section "The chain, stage by stage" alongside this flowgraph.
  states: {}
- name: note_mode
  id: note
  parameters:
    note: 'MODE IS FIXED AT: 8K / 16QAM / CR 2/3 / GI 1/32  ->  16.086 Mbit/s. The transmitter MUST match all four. These are GRC enums, so changing mode means editing SIX blocks together.'
    comment: A mode mismatch does not produce an error message - it produces silence. Check this first.
  states: {}
- name: note_video
  id: note
  parameters:
    note: 'Live picture needs ffmpeg:   sudo apt install ffmpeg   Without it the flowgraph still runs, still measures, and still records the .ts file.'
    comment: Everything except the picture works with no external tools.
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 64e6 / 7
    comment: 'DVB-T elementary rate for an 8 MHz channel: 64/7 = 9.142857 MSPS, one sample per elementary period T. Not negotiable - it defines the OFDM carrier spacing.'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '8192'
    comment: '8K mode: 8192 carriers, of which 6817 are transmitted and 6048 carry data. Long symbols (896 us) survive long echoes - which is what lets a single-frequency network work.'
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: fft_len // 32
    comment: Guard interval 1/32 = 256 samples = 28 us, so echoes up to 8.4 km of extra path are harmless.
  states: {}
- name: occupied
  id: variable
  parameters:
    value: '6817'
    comment: Transmitted carriers (Kmax-Kmin+1) in 8K mode.
  states: {}
- name: payload
  id: variable
  parameters:
    value: '6048'
    comment: Data cells per OFDM symbol, after pilots and TPS are removed.
  states: {}
- name: ts_file
  id: variable
  parameters:
    value: '''/tmp/lab11_rx.ts'''
    comment: Decoded transport stream is written here as well as played. Set to '' to disable recording.
  states: {}
- name: play_video
  id: variable
  parameters:
    value: 'True'
    comment: Spawn ffplay on the decoded stream. Set False to measure without a picture.
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 474e6 + 8e6 * (channel - 21)
    comment: 'UHF channel plan used across Europe, Malaysia and most of Asia-Pacific: channel 21 is centred on 474 MHz and every channel is 8 MHz wide.'
  states: {}
- name: channel
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: '"UHF channel"'
    rangeType: int
    start: '21'
    step: '1'
    stop: '48'
    value: '31'
    comment: Change channel. The USRP retunes immediately - this is the "seek" control. Channel 21-48 covers 470-694 MHz, the band left to television after the 700 MHz clearance.
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: '"RX gain (dB)"'
    start: '0'
    step: '1'
    stop: '76'
    value: '45'
    comment: 'Receive gain in dB. Raise until MER stops improving, then stop: past that point you are amplifying the noise floor along with the signal.'
  states: {}
- name: usrp
  id: uhd_usrp_source
  parameters:
    dev_addr: '"num_recv_frames=512"'
    clock_rate: '0.0'
    samp_rate: samp_rate
    center_freq0: center_freq
    gain0: rx_gain
    ant0: RX2
    bw0: samp_rate
    comment: 'The radio. Note bw0 = samp_rate: without it the AD9361 keeps its 56 MHz default analog bandwidth and the neighbouring TV channels fold into this one.'
    type: fc32
  states: {}
- name: acq
  id: dtv_dvbt_ofdm_sym_acquisition
  parameters:
    type: complex
    fft_length: fft_len
    occupied_tones: occupied
    cp_length: cp_len
    snr: '10'
    comment: Finds the OFDM symbol boundary by correlating the cyclic prefix against the end of the symbol, and corrects the fractional frequency offset. Everything downstream assumes this has locked.
  states: {}
- name: ofdm_fft
  id: fft_vxx
  parameters:
    comment: Back to the frequency domain, where the pilots live. shift=True puts DC in the middle, which is what the pilot demodulator expects.
    type: complex
    fft_size: fft_len
    forward: 'True'
    window: window.rectangular(fft_len)
    shift: 'True'
  states: {}
- name: pilots
  id: dtv_dvbt_demod_reference_signals
  parameters:
    cell_id: '0'
    comment: Uses the scattered and continual pilots to equalise every carrier, reads the TPS carriers to confirm the mode, and strips the pilots out. Outputs 6048 equalised data cells.
    type: complex
    transmission_mode: T8k
    constellation: 16qam
    hierarchy: nh
    code_rate_hp: C2_3
    code_rate_lp: C2_3
    guard_interval: GI_1_32
    include_cell_id: call_id_yes
  states: {}
- name: demap
  id: dtv_dvbt_demap
  parameters:
    gain: '1'
    comment: Constellation points back to bits.
    transmission_mode: T8k
    constellation: 16qam
    hierarchy: nh
  states: {}
- name: symdeint
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    comment: 'Symbol DE-interleaver (direction = Deinterleave). Leaving this block out is the classic DVB-T receiver bug: the transport stream still gets a 0x47 on every packet, because the energy descrambler writes it unconditionally, while every payload byte is noise.'
    transmission_mode: T8k
    direction: Deinterleave
  states: {}
- name: bitdeint
  id: dtv_dvbt_bit_inner_deinterleaver
  parameters:
    comment: Undoes the per-bit-position interleaving inside each QAM symbol.
    transmission_mode: T8k
    constellation: 16qam
  states: {}
- name: v2s
  id: blocks_vector_to_stream
  parameters:
    num_items: payload
    comment: Vectors of 6048 soft bits become a byte stream for the Viterbi decoder.
    type: byte
  states: {}
- name: viterbi
  id: dtv_dvbt_viterbi_decoder
  parameters:
    comment: 'The inner convolutional decoder - the heaviest block in the chain. This is what sets the real-time limit: measured at 16.4 MSPS against the 9.14 MSPS needed, so 1.8x margin.'
    constellation: 16qam
    hierarchy: nh
    code_rate: C2_3
    type: b
    block_size: '768'
  states: {}
- name: convdeint
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    blocks: '136'
    I: '12'
    M: '17'
    comment: Spreads each burst error across 12 Reed-Solomon blocks, so a fade that would destroy one packet instead puts a few correctable bytes into each of twelve.
  states: {}
- name: rs
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    p: '2'
    m: '8'
    gfpoly: '0x11d'
    n: '255'
    k: '239'
    t: '8'
    s: '51'
    blocks: '8'
    comment: 'RS(204,188) over GF(2^8): corrects up to 8 wrong bytes per packet. If it gives up, the packet is lost - which is what the continuity counter then reveals.'
  states: {}
- name: descramble
  id: dtv_dvbt_energy_descramble
  parameters:
    nsize: '8'
    comment: Removes the PRBS that spread the spectrum, and restores the transport packet sync bytes.
  states: {}
- name: tv_out
  id: epy_block
  parameters:
    _source_code: |
      """Transport-stream sink: statistics, an optional file, and live video.

      Two things here are deliberate and worth copying.

      **It never blocks the radio.**  Pointing a File Sink at a FIFO is the obvious
      way to feed a player and it is a trap: if the player pauses or dies, the write
      blocks, the scheduler stops draining the USRP, and the receiver drowns in
      overflows.  A bounded queue absorbs jitter and *drops* when the player falls
      behind.  Dropping television frames is the correct failure -- the radio keeps
      running and the picture recovers at the next keyframe.

      **It counts continuity errors, not sync bytes.**  Every packet leaving a DVB-T
      receiver starts with 0x47 whether or not the decode worked, because the energy
      descrambler writes that byte unconditionally.  The honest measure of link
      health is the continuity counter: 4 bits per PID that increment on every
      packet, so a jump means Reed-Solomon gave up on a block.
      """
      import queue
      import subprocess
      import threading

      import numpy as np
      from gnuradio import gr

      PLAYER = ['ffplay', '-hide_banner', '-loglevel', 'error', '-fflags', 'nobuffer',
                '-flags', 'low_delay', '-framedrop', '-autoexit',
                '-window_title', 'SDR LAB TV', '-i', 'pipe:0']


      class blk(gr.sync_block):
          def __init__(self, play=True, ts_file='', report_every=20000):
              gr.sync_block.__init__(self, name='TV Output + TS Stats',
                                     in_sig=[np.uint8], out_sig=None)
              self.set_output_multiple(188)
              self.report_every = int(report_every)
              self.packets = self.cc_errors = self.sync_errors = self.dropped = 0
              self.pids = {}
              self._cc = {}
              self._buf = b''
              self._since = 0
              self._q = queue.Queue(maxsize=256)
              self._fh = open(ts_file, 'wb') if ts_file else None
              self._proc = None
              if play:
                  try:
                      self._proc = subprocess.Popen(PLAYER, stdin=subprocess.PIPE,
                                                    stdout=subprocess.DEVNULL,
                                                    stderr=subprocess.DEVNULL)
                  except FileNotFoundError:
                      print('[TV] ffplay not found -- install ffmpeg for live video '
                            '(sudo apt install ffmpeg). Recording only.')
              threading.Thread(target=self._drain, daemon=True).start()

          def _drain(self):
              while True:
                  chunk = self._q.get()
                  for sink in (self._proc.stdin if self._proc else None, self._fh):
                      if sink is None:
                          continue
                      try:
                          sink.write(chunk)
                      except (BrokenPipeError, ValueError, OSError):
                          pass

          def work(self, input_items, output_items):
              data = input_items[0].tobytes()
              try:
                  self._q.put_nowait(data)
              except queue.Full:
                  self.dropped += 1
              buf = self._buf + data
              n = len(buf) // 188
              for k in range(n):
                  p = buf[k * 188:(k + 1) * 188]
                  self.packets += 1
                  self._since += 1
                  if p[0] != 0x47:
                      self.sync_errors += 1
                      continue
                  pid = ((p[1] & 0x1f) << 8) | p[2]
                  self.pids[pid] = self.pids.get(pid, 0) + 1
                  if pid != 0x1fff and (p[3] & 0x10):
                      cc = p[3] & 0x0f
                      prev = self._cc.get(pid)
                      if prev is not None and cc != (prev + 1) % 16:
                          self.cc_errors += 1
                      self._cc[pid] = cc
              self._buf = buf[n * 188:]
              if self._since >= self.report_every:
                  self._since = 0
                  self._report()
              return len(input_items[0])

          def _report(self):
              top = sorted(self.pids.items(), key=lambda kv: -kv[1])[:6]
              rate = self.cc_errors / max(1, self.packets)
              health = 'LOCKED  ' if rate < 1e-4 else ('marginal' if rate < 1e-2 else 'NO LOCK ')
              print(f'[TV] {health} {self.packets:>9,} pkts  '
                    f'CC err {self.cc_errors:>7,} ({rate:.2e})  '
                    f'sync err {self.sync_errors:>6,}  dropped {self.dropped:>4}')
              print('     PIDs: ' + '  '.join(
                  f'{p}{"(null)" if p == 8191 else ""}:{c*100.0/max(1,self.packets):.1f}%'
                  for p, c in top))
    comment: 'Statistics, recording and live video in one block. Read its source: it explains why a File Sink on a FIFO would stall the radio, and why continuity errors - not sync bytes - are the measure of link health.'
    play: play_video
    ts_file: ts_file
    report_every: '20000'
  states: {}
- name: cells
  id: blocks_vector_to_stream
  parameters:
    num_items: payload
    comment: Tap the equalised data cells so they can be drawn and measured.
    type: complex
  states: {}
- name: mer
  id: epy_block
  parameters:
    _source_code: |
      """Modulation Error Ratio, the number a television calls "signal quality".

          MER = 10 log10( mean |ideal|^2 / mean |received - ideal|^2 )

      `ideal` is the nearest legal constellation point, so no knowledge of the
      transmitted data is needed.  Measured against a calibrated AWGN channel this
      tracks true SNR to within about 0.9 dB.

      Watch this rather than the picture.  MER falls smoothly as the link degrades,
      while the picture stays flawless and then collapses: for 16QAM CR 2/3 this
      receiver decodes perfectly at 13 dB and fails completely at 12 dB.  By the
      time the picture breaks up you have already lost all your margin.
      """
      import numpy as np
      from gnuradio import gr

      LEVELS = {2: np.array([-1., 1.]) / np.sqrt(2),
                4: np.array([-3., -1., 1., 3.]) / np.sqrt(10),
                6: np.array([-7., -5., -3., -1., 1., 3., 5., 7.]) / np.sqrt(42)}


      class blk(gr.decim_block):
          def __init__(self, bits_per_symbol=4, decim=4096):
              gr.decim_block.__init__(self, name='MER (dB)',
                                      in_sig=[np.complex64], out_sig=[np.float32],
                                      decim=int(decim))
              self.decim = int(decim)       # own copy: decim_block has no decimation() here
              self.levels = LEVELS[int(bits_per_symbol)]
              self.mer = 0.0

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              x = input_items[0][:n * self.decim:8]   # 1 in 8 is plenty for a reading, and 8x cheaper
              if len(x) > 8192:                      # a measurement, not a filter:
                  x = x[::len(x) // 8192]            # sub-sampling costs nothing
              if len(x):
                  lv = self.levels
                  i = lv[np.abs(x.real[:, None] - lv[None, :]).argmin(axis=1)]
                  q = lv[np.abs(x.imag[:, None] - lv[None, :]).argmin(axis=1)]
                  ideal = i + 1j * q
                  err = float(np.mean(np.abs(x - ideal) ** 2))
                  sig = float(np.mean(np.abs(ideal) ** 2))
                  if err > 0 and sig > 0:
                      m = 10 * np.log10(sig / err)
                      self.mer = m if self.mer == 0.0 else 0.9 * self.mer + 0.1 * m
              out[:] = self.mer
              return n
    comment: Modulation Error Ratio in dB - the honest version of a TV signal-quality bar.
    bits_per_symbol: '4'
    decim: '4096'
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Channel spectrum"'
    fftsize: '4096'
    fc: center_freq
    bw: samp_rate
    average: '0.2'
    ymin: '-110'
    ymax: '-20'
    comment: The channel as received. A healthy DVB-T signal is a flat 7.6 MHz slab with steep shoulders; if it looks like a hill, you are looking at the noise floor.
    gui_hint: 1,0,1,1
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: '"Waterfall"'
    fftsize: '2048'
    fc: center_freq
    bw: samp_rate
    int_min: '-110'
    int_max: '-30'
    comment: Time against frequency. Broadcast TV is a solid continuous band; bursts and gaps mean you have found something else.
    gui_hint: 1,1,1,1
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: '"Constellation"'
    size: '2048'
    tr_slope: qtgui.TRIG_MODE_POS
    comment: '16QAM: sixteen tight dots when the link is healthy. Fuzzy blobs = low MER. A rotating pattern = frequency error. A warped grid = the equaliser is struggling with a reflection.'
    gui_hint: 2,0,1,1
  states: {}
- name: mer_display
  id: qtgui_number_sink
  parameters:
    name: '"Signal quality"'
    min: '0'
    max: '40'
    comment: MER in dB. For 16QAM CR 2/3 this receiver is perfect at 13 dB and dead at 12 dB. Anything above 20 dB is comfortable; below 15 dB you are one rain shower from losing it.
    type: float
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"MER"'
    unit1: '"dB"'
    gui_hint: 2,1,1,1
  states: {}
- name: pwr
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Instantaneous power.
  states: {}
- name: pwr_dec
  id: blocks_keep_one_in_n
  parameters:
    n: '4096'
    comment: One sample in 4096 is plenty for a level meter.
    type: float
  states: {}
- name: pwr_avg
  id: single_pole_iir_filter_xx
  parameters:
    comment: Smooth it, or the number is unreadable.
    type: float
    alpha: '0.02'
  states: {}
- name: pwr_db
  id: blocks_nlog10_ff
  parameters:
    n: '10'
    k: '0'
    comment: Into dBFS.
  states: {}
- name: level_display
  id: qtgui_number_sink
  parameters:
    name: '"Level"'
    min: '-100'
    max: '0'
    comment: 'Received level in dBFS. Use it to set gain: raise gain until this reads about -30 dBFS, and watch that MER improves as you do. If level rises but MER does not, you are amplifying noise.'
    type: float
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"Level"'
    unit1: '"dBFS"'
    gui_hint: 3,0,1,2
  states: {}

connections:
- [usrp, '0', acq, '0']
- [acq, '0', ofdm_fft, '0']
- [ofdm_fft, '0', pilots, '0']
- [pilots, '0', demap, '0']
- [demap, '0', symdeint, '0']
- [symdeint, '0', bitdeint, '0']
- [bitdeint, '0', v2s, '0']
- [v2s, '0', viterbi, '0']
- [viterbi, '0', convdeint, '0']
- [convdeint, '0', rs, '0']
- [rs, '0', descramble, '0']
- [descramble, '0', tv_out, '0']
- [pilots, '0', cells, '0']
- [cells, '0', mer, '0']
- [usrp, '0', spectrum, '0']
- [usrp, '0', waterfall, '0']
- [cells, '0', constellation, '0']
- [mer, '0', mer_display, '0']
- [usrp, '0', pwr, '0']
- [pwr, '0', pwr_dec, '0']
- [pwr_dec, '0', pwr_avg, '0']
- [pwr_avg, '0', pwr_db, '0']
- [pwr_db, '0', level_display, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
