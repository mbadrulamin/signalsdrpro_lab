options:
  parameters:
    id: lab01_simple_wbfm
    title: Lab 01 - Simplest WBFM Receiver (SignalSDR Pro as B210)
    author: SignalSDR Pro Lab
    description: Minimal FM broadcast receiver using SignalSDR Pro emulating USRP B210
    generate_options: qt_gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate from USRP (1 MSPS for FM broadcast)
    value: '1000000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: FM broadcast band is 87.5-108 MHz. Stations sit 100 kHz apart (200 kHz in the US).
    label: FM Station (Hz)
    start: 87.5e6
    stop: 108e6
    step: 100e3
    value: 100.0e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: Start at 40 dB. Raise until the noise floor starts rising with it, then back off - see Fundamentals 06.
    label: RF Gain (dB)
    start: '0'
    stop: '76'
    step: '1'
    value: '40'
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    comment: 'The only hardware block. fc32 = complex float32 IQ, the format every later lab assumes. Also sets the AD9361 analog filter to samp_rate: without that it defaults to 56 MHz and LO/DC leakage dominates (measured 0.84 of total power vs 0.16).'
    type: fc32
    dev_args: '""'
    samp_rate: samp_rate
    sync: none
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    gain0: gain
  states: {}
- name: wbfm_rcv
  id: analog_wfm_rcv
  parameters:
    comment: Quadrature demod + de-emphasis + audio filter in one block. 1000000/20 = 50000 audio.
    quad_rate: samp_rate
    audio_decimation: '20'
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    comment: 'Must match the WBFM output rate exactly: samp_rate / audio_decimation = 50000.'
    samp_rate: '50000'
    device_name: '""'
  states: {}

connections:
- [usrp_source, '0', wbfm_rcv, '0']
- [wbfm_rcv, '0', audio_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
