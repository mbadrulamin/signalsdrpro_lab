options:
  parameters:
    id: lab01_simple_wbfm
    title: Lab 01 - Simplest WBFM Receiver (SignalSDR Pro as B210)
    author: SignalSDR Pro Lab
    description: Minimal FM broadcast receiver using SignalSDR Pro emulating USRP B210
    generate_options: qt_gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 'Sample rate: 1 million IQ samples per second (1 MSPS). With IQ, that shows 1 MHz of spectrum - room for one FM station and its neighbours.'
    value: '1000000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: The station to listen to. FM radio is 87.5-108 MHz. Stations sit on a 100 kHz grid (89.9, 90.0 ...) and each one is about 200 kHz wide.
    label: FM Station (Hz)
    start: 87.5e6
    stop: 108e6
    step: 100e3
    value: 100.0e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: 'How much the radio amplifies. Start at 40 dB. Gain is NOT volume: too much distorts. See Fundamentals 06.'
    label: RF Gain (dB)
    start: '0'
    stop: '76'
    step: '1'
    value: '40'
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    comment: 'The radio itself: gives 1 million IQ samples per second (complex float32). It also sets the radio''s hardware filter (bw0) to the sample rate - leave that empty and the filter opens to 56 MHz, and the centre spike becomes 84% of everything received (16% when set).'
    type: fc32
    dev_args: '""'
    samp_rate: samp_rate
    sync: none
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    gain0: gain
  states: {}
- name: wbfm_rcv
  id: analog_wfm_rcv
  parameters:
    comment: 'The FM decoder: turns IQ into sound (FM demodulation + audio filter + de-emphasis, all in one). 1,000,000 / 20 = 50,000 audio samples per second.'
    quad_rate: samp_rate
    audio_decimation: '20'
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    comment: 'Your speakers. The rate must equal what WBFM Receive outputs: 1,000,000 / 20 = 50,000.'
    samp_rate: '50000'
    device_name: '""'
  states: {}

connections:
- [usrp_source, '0', wbfm_rcv, '0']
- [wbfm_rcv, '0', audio_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
