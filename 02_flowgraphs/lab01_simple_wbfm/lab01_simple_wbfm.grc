options:
  parameters:
    id: lab01_simple_wbfm
    title: Lab 01 - Simplest WBFM Receiver (SignalSDR Pro as B210)
    author: SignalSDR Pro Lab
    description: Minimal FM broadcast receiver using SignalSDR Pro emulating USRP B210
    generate_options: qt_gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate from USRP (1 MSPS for FM broadcast)
    value: '1000000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: FM Station (Hz)
    start: 87.5e6
    stop: 108e6
    step: 100e3
    value: 100.0e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (dB)
    start: '0'
    stop: '76'
    step: '1'
    value: '40'
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    type: fc32
    dev_args: '""'
    samp_rate: samp_rate
    sync: none
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: gain
  states: {}
- name: wbfm_rcv
  id: analog_wfm_rcv
  parameters:
    quad_rate: samp_rate
    audio_decimation: '20'
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '50000'
    device_name: '""'
  states: {}

connections:
- [usrp_source, '0', wbfm_rcv, '0']
- [wbfm_rcv, '0', audio_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
