options:
  parameters:
    id: lab12_fullduplex_tv
    title: Lab 12 - Full-Duplex DVB-T Video Link (TRANSMITS - contained environment only)
    author: SignalSDR Pro Lab
    description: Transmit a video file as DVB-T and receive it back on the same radio, simultaneously
    generate_options: qt_gui
    output_language: python
  states: {}

blocks:
- name: note_legal
  id: note
  parameters:
    note: 'THIS TRANSMITS. DVB-T occupies 8 MHz of licensed broadcast spectrum. Faraday cage, or cable plus 40-60 dB attenuator. Never into an antenna on an active TV channel. Scan first: 03_scripts/scan_tv_band.py'
    comment: Read the README safety section before raising either transmit slider.
  states: {}
- name: note_interlock
  id: note
  parameters:
    note: 'SAFETY INTERLOCK: tx_amplitude and tx_gain both start at 0. The flowgraph radiates nothing until you deliberately raise them. Check what is on the TX/RX port first.'
    comment: The inert defaults are the interlock, not an inconvenience.
  states: {}
- name: note_duplex
  id: note
  parameters:
    note: 'FULL DUPLEX on one SignalSDR Pro: transmit on TX/RX, receive on RX2, simultaneously. Both share one reference oscillator, so the receiver sees ZERO frequency offset - the easiest possible synchronisation, and an unrealistically kind one.'
    comment: A real receiver must hunt for the carrier. Here it never has to. See README.
  states: {}
- name: note_ts
  id: note
  parameters:
    note: |-
      Feed it video:  03_scripts/make_video_ts.py ~/Downloads/Bintang.mp4 /tmp/bintang.ts --mode 16qam-2/3-1/32
      For anything longer than one pass of the file, use continuous playout instead:
        03_scripts/tv_playout.py ~/Downloads/Bintang.mp4 --standard dvbt --mode 16qam-2/3-1/32 --fifo /tmp/tv.fifo
      A looping .ts sends the PCR BACKWARD by the file's length at every lap (measured -208.86 s).
    comment: Without ffmpeg use 03_scripts/make_test_ts.py for a valid but pictureless stream.
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 64e6 / 7
    comment: 'DVB-T elementary rate for an 8 MHz channel: 9.142857 MSPS. Both directions run at this rate, so the USB link carries 2 x 9.14 MSPS x 8 bytes = 146 MB/s. USB 3.0 only.'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '8192'
    comment: 8K mode.
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: fft_len // 32
    comment: Guard interval 1/32 = 256 samples.
  states: {}
- name: occupied
  id: variable
  parameters:
    value: '6817'
    comment: Transmitted carriers.
  states: {}
- name: payload
  id: variable
  parameters:
    value: '6048'
    comment: Data cells per symbol.
  states: {}
- name: ts_in
  id: variable
  parameters:
    value: '''/tmp/bintang.ts'''
    comment: Transport stream to transmit. MUST be muxed at exactly 16.086 Mbit/s for this mode. A file is right for the byte-exact verification in the README, because you need something to compare against; for sustained viewing use tv_playout.py and point this at its FIFO, or the clock restarts every lap.
  states: {}
- name: ts_out
  id: variable
  parameters:
    value: '''/tmp/lab12_rx.ts'''
    comment: Received stream is recorded here.
  states: {}
- name: play_video
  id: variable
  parameters:
    value: 'True'
    comment: Spawn ffplay on the received stream.
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 474e6 + 8e6 * (channel - 21)
    comment: Same 8 MHz UHF raster as Lab 11. Transmit and receive on the same channel.
  states: {}
- name: channel
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: '"UHF channel"'
    rangeType: int
    start: '21'
    step: '1'
    stop: '48'
    value: '31'
    comment: Both ends retune together - they are the same radio.
  states: {}
- name: tx_amplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: '"TX amplitude (0 = off)"'
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0'
    comment: Digital amplitude BEFORE the DAC. Starts at 0. At 1.0 the waveform has RMS 0.21 and peak 0.81 - deliberately backed off, because OFDM has 11 dB of peak-to-average ratio and clipping the peaks splatters into the neighbouring channels.
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: '"TX gain (dB)"'
    start: '0'
    step: '1'
    stop: '89'
    value: '0'
    comment: Analog transmit gain in dB. Starts at 0. Raise this LAST, and only as far as the receiver needs. Over a short cable, 0 dB is usually already too much.
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: '"RX gain (dB)"'
    start: '0'
    step: '1'
    stop: '76'
    value: '20'
    comment: Receive gain in dB. With the transmitter a few metres away this wants to be LOW - the usual failure here is overload, not weak signal.
  states: {}
- name: ts_src
  id: blocks_file_source
  parameters:
    repeat: 'True'
    comment: The transport stream, looping forever. The modulator pulls bytes at exactly the rate the mode defines, so this file is a queue the hardware drains - not a clock.
    file: ts_in
    type: byte
  states: {}
- name: tx_energy
  id: dtv_dvbt_energy_dispersal
  parameters:
    nsize: '1'
    comment: XOR with a PRBS so a static picture cannot put a spectral line in the middle of the channel.
  states: {}
- name: tx_rs
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    p: '2'
    m: '8'
    gfpoly: '0x11d'
    n: '255'
    k: '239'
    t: '8'
    s: '51'
    blocks: '8'
    comment: 'RS(204,188): 16 parity bytes per packet, correcting up to 8 wrong bytes.'
  states: {}
- name: tx_ci
  id: dtv_dvbt_convolutional_interleaver
  parameters:
    blocks: '136'
    I: '12'
    M: '17'
    comment: Spreads each packet over 12 branches so an impulse hits many RS blocks slightly instead of one block fatally.
  states: {}
- name: tx_inner
  id: dtv_dvbt_inner_coder
  parameters:
    ninput: '1'
    noutput: payload
    comment: Rate 2/3 punctured convolutional code - the main error protection.
    constellation: 16qam
    hierarchy: nh
    code_rate: C2_3
  states: {}
- name: tx_bi
  id: dtv_dvbt_bit_inner_interleaver
  parameters:
    comment: 'Decorrelates bit positions within each QAM symbol: the outer bits of a 16QAM point are much more reliable than the inner ones, and this shares that unfairness out.'
    transmission_mode: T8k
    constellation: 16qam
  states: {}
- name: tx_si
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    comment: Scatters adjacent bits across all 6048 carriers, so a notch from a reflection removes isolated bits the Viterbi decoder can repair rather than a contiguous run it cannot.
    transmission_mode: T8k
    direction: Interleave
  states: {}
- name: tx_map
  id: dtv_dvbt_map
  parameters:
    gain: '1'
    comment: Bits to 16QAM constellation points.
    transmission_mode: T8k
    constellation: 16qam
    hierarchy: nh
  states: {}
- name: tx_pilots
  id: dtv_dvbt_reference_signals
  parameters:
    cell_id: '0'
    comment: 'Inserts scattered pilots, continual pilots and the TPS carriers - AND performs the IFFT. Its output is TIME domain. Adding an FFT block after it looks symmetrical with the receiver and silently destroys the signal: the OFDM timing still looks right to a cyclic-prefix detector, so the only symptom is that the frame synchroniser never locks.'
    type: complex
    transmission_mode: T8k
    constellation: 16qam
    hierarchy: nh
    code_rate_hp: C2_3
    code_rate_lp: C2_3
    guard_interval: GI_1_32
    include_cell_id: call_id_yes
  states: {}
- name: tx_cp
  id: digital_ofdm_cyclic_prefixer
  parameters:
    input_size: fft_len
    cp_len: cp_len
    tagname: ''
    comment: Copies the last 256 samples to the front of each symbol. This is what turns a multipath channel into a simple per-carrier multiply at the receiver.
  states: {}
- name: tx_skip
  id: blocks_skiphead
  parameters:
    num_items: fft_len + cp_len
    comment: Drop the first OFDM symbol. Measured, it carries a start-up transient with a peak of 8.1 against a steady-state RMS of 0.21 - a 31 dB spike where OFDM normally runs 11 dB. Sending it clips the DAC on the very first sample.
    type: complex
  states: {}
- name: tx_amp
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amplitude
    comment: The interlock. 0 means nothing leaves the DAC.
    type: complex
  states: {}
- name: usrp_tx
  id: uhd_usrp_sink
  parameters:
    dev_addr: '"send_frame_size=8192,num_send_frames=256"'
    clock_rate: '0.0'
    samp_rate: samp_rate
    center_freq0: center_freq
    gain0: tx_gain
    bw0: samp_rate
    comment: Transmit on the TX/RX port. bw0 = samp_rate keeps the analog reconstruction filter tight; without it the AD9361 leaves 56 MHz open and images land on other TV channels.
    type: fc32
    ant0: TX/RX
  states: {}
- name: usrp_rx
  id: uhd_usrp_source
  parameters:
    dev_addr: '"num_recv_frames=512"'
    clock_rate: '0.0'
    samp_rate: samp_rate
    center_freq0: center_freq
    gain0: rx_gain
    ant0: RX2
    bw0: samp_rate
    comment: 'Receive on RX2 while TX/RX transmits - that is the full-duplex part. Measured sustained: 9.14 MSPS in each direction simultaneously over USB 3.0.'
    type: fc32
  states: {}
- name: rx_acq
  id: dtv_dvbt_ofdm_sym_acquisition
  parameters:
    type: complex
    fft_length: fft_len
    occupied_tones: occupied
    cp_length: cp_len
    snr: '10'
    comment: Cyclic-prefix symbol timing and fine frequency correction.
  states: {}
- name: rx_fft
  id: fft_vxx
  parameters:
    comment: Back to the frequency domain, DC centred.
    type: complex
    fft_size: fft_len
    forward: 'True'
    window: window.rectangular(fft_len)
    shift: 'True'
  states: {}
- name: rx_pilots
  id: dtv_dvbt_demod_reference_signals
  parameters:
    cell_id: '0'
    comment: Pilot-based equalisation, TPS read-out, pilots stripped.
    type: complex
    transmission_mode: T8k
    constellation: 16qam
    hierarchy: nh
    code_rate_hp: C2_3
    code_rate_lp: C2_3
    guard_interval: GI_1_32
    include_cell_id: call_id_yes
  states: {}
- name: rx_demap
  id: dtv_dvbt_demap
  parameters:
    gain: '1'
    comment: Constellation points back to bits.
    transmission_mode: T8k
    constellation: 16qam
    hierarchy: nh
  states: {}
- name: rx_si
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    comment: Symbol DE-interleaver. Omitting it yields a transport stream with perfect sync bytes and pure noise for payload.
    transmission_mode: T8k
    direction: Deinterleave
  states: {}
- name: rx_bi
  id: dtv_dvbt_bit_inner_deinterleaver
  parameters:
    comment: Bit de-interleaver.
    transmission_mode: T8k
    constellation: 16qam
  states: {}
- name: rx_v2s
  id: blocks_vector_to_stream
  parameters:
    num_items: payload
    comment: Vectors to a byte stream for the Viterbi decoder.
    type: byte
  states: {}
- name: rx_viterbi
  id: dtv_dvbt_viterbi_decoder
  parameters:
    comment: 'The heaviest block in the flowgraph, and what sets the real-time limit: 16.4 MSPS measured against 9.14 needed.'
    constellation: 16qam
    hierarchy: nh
    code_rate: C2_3
    type: b
    block_size: '768'
  states: {}
- name: rx_cd
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    blocks: '136'
    I: '12'
    M: '17'
    comment: Undo the convolutional interleaving.
  states: {}
- name: rx_rs
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    p: '2'
    m: '8'
    gfpoly: '0x11d'
    n: '255'
    k: '239'
    t: '8'
    s: '51'
    blocks: '8'
    comment: Correct up to 8 byte errors per packet.
  states: {}
- name: rx_desc
  id: dtv_dvbt_energy_descramble
  parameters:
    nsize: '8'
    comment: Undo the PRBS, restore sync bytes.
  states: {}
- name: tv_out
  id: epy_block
  parameters:
    _source_code: |
      """Transport-stream sink: statistics, an optional file, and live video.

      Two things here are deliberate and worth copying.

      **It never blocks the radio.**  Pointing a File Sink at a FIFO is the obvious
      way to feed a player and it is a trap: if the player pauses or dies, the write
      blocks, the scheduler stops draining the USRP, and the receiver drowns in
      overflows.  A bounded queue absorbs jitter and *drops* when the player falls
      behind.  Dropping television frames is the correct failure -- the radio keeps
      running and the picture recovers at the next keyframe.

      **It counts continuity errors, not sync bytes.**  Every packet leaving a DVB-T
      receiver starts with 0x47 whether or not the decode worked, because the energy
      descrambler writes that byte unconditionally.  The honest measure of link
      health is the continuity counter: 4 bits per PID that increment on every
      packet, so a jump means Reed-Solomon gave up on a block.
      """
      import queue
      import subprocess
      import threading

      import numpy as np
      from gnuradio import gr

      PLAYER = ['ffplay', '-hide_banner', '-loglevel', 'error', '-fflags', 'nobuffer',
                '-flags', 'low_delay', '-framedrop', '-autoexit',
                '-window_title', 'SDR LAB TV', '-i', 'pipe:0']


      class blk(gr.sync_block):
          def __init__(self, play=True, ts_file='', report_every=20000):
              gr.sync_block.__init__(self, name='TV Output + TS Stats',
                                     in_sig=[np.uint8], out_sig=None)
              self.set_output_multiple(188)
              self.report_every = int(report_every)
              self.packets = self.cc_errors = self.sync_errors = self.dropped = 0
              self.pids = {}
              self._cc = {}
              self._buf = b''
              self._since = 0
              self._q = queue.Queue(maxsize=256)
              self._fh = open(ts_file, 'wb') if ts_file else None
              self._proc = None
              if play:
                  try:
                      self._proc = subprocess.Popen(PLAYER, stdin=subprocess.PIPE,
                                                    stdout=subprocess.DEVNULL,
                                                    stderr=subprocess.DEVNULL)
                  except FileNotFoundError:
                      print('[TV] ffplay not found -- install ffmpeg for live video '
                            '(sudo apt install ffmpeg). Recording only.')
              threading.Thread(target=self._drain, daemon=True).start()

          def _drain(self):
              while True:
                  chunk = self._q.get()
                  for sink in (self._proc.stdin if self._proc else None, self._fh):
                      if sink is None:
                          continue
                      try:
                          sink.write(chunk)
                      except (BrokenPipeError, ValueError, OSError):
                          pass

          def work(self, input_items, output_items):
              data = input_items[0].tobytes()
              try:
                  self._q.put_nowait(data)
              except queue.Full:
                  self.dropped += 1
              buf = self._buf + data
              n = len(buf) // 188
              for k in range(n):
                  p = buf[k * 188:(k + 1) * 188]
                  self.packets += 1
                  self._since += 1
                  if p[0] != 0x47:
                      self.sync_errors += 1
                      continue
                  pid = ((p[1] & 0x1f) << 8) | p[2]
                  self.pids[pid] = self.pids.get(pid, 0) + 1
                  if pid != 0x1fff and (p[3] & 0x10):
                      cc = p[3] & 0x0f
                      prev = self._cc.get(pid)
                      if prev is not None and cc != (prev + 1) % 16:
                          self.cc_errors += 1
                      self._cc[pid] = cc
              self._buf = buf[n * 188:]
              if self._since >= self.report_every:
                  self._since = 0
                  self._report()
              return len(input_items[0])

          def _report(self):
              top = sorted(self.pids.items(), key=lambda kv: -kv[1])[:6]
              rate = self.cc_errors / max(1, self.packets)
              health = 'LOCKED  ' if rate < 1e-4 else ('marginal' if rate < 1e-2 else 'NO LOCK ')
              print(f'[TV] {health} {self.packets:>9,} pkts  '
                    f'CC err {self.cc_errors:>7,} ({rate:.2e})  '
                    f'sync err {self.sync_errors:>6,}  dropped {self.dropped:>4}')
              print('     PIDs: ' + '  '.join(
                  f'{p}{"(null)" if p == 8191 else ""}:{c*100.0/max(1,self.packets):.1f}%'
                  for p, c in top))
    comment: 'The whole point: the transport stream that went into the transmitter, recovered from the air and handed to a player. If the picture is identical to the source file, every stage of both chains is correct.'
    play: play_video
    ts_file: ts_out
    report_every: '20000'
  states: {}
- name: rx_cells
  id: blocks_vector_to_stream
  parameters:
    num_items: payload
    comment: Tap the equalised cells.
    type: complex
  states: {}
- name: rx_mer
  id: epy_block
  parameters:
    _source_code: |
      """Modulation Error Ratio, the number a television calls "signal quality".

          MER = 10 log10( mean |ideal|^2 / mean |received - ideal|^2 )

      `ideal` is the nearest legal constellation point, so no knowledge of the
      transmitted data is needed.  Measured against a calibrated AWGN channel this
      tracks true SNR to within about 0.9 dB.

      Watch this rather than the picture.  MER falls smoothly as the link degrades,
      while the picture stays flawless and then collapses: for 16QAM CR 2/3 this
      receiver decodes perfectly at 13 dB and fails completely at 12 dB.  By the
      time the picture breaks up you have already lost all your margin.
      """
      import numpy as np
      from gnuradio import gr

      LEVELS = {2: np.array([-1., 1.]) / np.sqrt(2),
                4: np.array([-3., -1., 1., 3.]) / np.sqrt(10),
                6: np.array([-7., -5., -3., -1., 1., 3., 5., 7.]) / np.sqrt(42)}


      class blk(gr.decim_block):
          def __init__(self, bits_per_symbol=4, decim=4096):
              gr.decim_block.__init__(self, name='MER (dB)',
                                      in_sig=[np.complex64], out_sig=[np.float32],
                                      decim=int(decim))
              self.decim = int(decim)       # own copy: decim_block has no decimation() here
              self.levels = LEVELS[int(bits_per_symbol)]
              self.mer = 0.0

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              x = input_items[0][:n * self.decim:8]   # 1 in 8 is plenty for a reading, and 8x cheaper
              if len(x) > 8192:                      # a measurement, not a filter:
                  x = x[::len(x) // 8192]            # sub-sampling costs nothing
              if len(x):
                  lv = self.levels
                  i = lv[np.abs(x.real[:, None] - lv[None, :]).argmin(axis=1)]
                  q = lv[np.abs(x.imag[:, None] - lv[None, :]).argmin(axis=1)]
                  ideal = i + 1j * q
                  err = float(np.mean(np.abs(x - ideal) ** 2))
                  sig = float(np.mean(np.abs(ideal) ** 2))
                  if err > 0 and sig > 0:
                      m = 10 * np.log10(sig / err)
                      self.mer = m if self.mer == 0.0 else 0.9 * self.mer + 0.1 * m
              out[:] = self.mer
              return n
    comment: Signal quality in dB.
    bits_per_symbol: '4'
    decim: '4096'
  states: {}
- name: rx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Received spectrum"'
    fftsize: '4096'
    fc: center_freq
    bw: samp_rate
    average: '0.2'
    ymin: '-110'
    ymax: '-10'
    comment: 'What comes back. Compare it with the transmit spectrum below: same shape, lower level, plus whatever the room added.'
    gui_hint: 1,0,1,2
  states: {}
- name: tx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Transmitted spectrum"'
    fftsize: '4096'
    fc: center_freq
    bw: samp_rate
    average: '0.2'
    ymin: '-120'
    ymax: '0'
    comment: 'What goes out: a flat 7.6 MHz slab with steep shoulders. If the shoulders are not steep, tx_amplitude is clipping and you are interfering with the neighbours.'
    gui_hint: 2,0,1,2
  states: {}
- name: rx_const
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: '"Received constellation"'
    size: '2048'
    tr_slope: qtgui.TRIG_MODE_POS
    comment: Sixteen dots when the loop is healthy. Smeared = too much gain somewhere; this link usually fails by overload, not weakness.
    gui_hint: 3,0,1,1
  states: {}
- name: rx_mer_display
  id: qtgui_number_sink
  parameters:
    name: '"Signal quality"'
    min: '0'
    max: '40'
    comment: MER in dB. Perfect above 13 dB for this mode; dead below 12. On a short cable expect 25 dB+.
    type: float
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"MER"'
    unit1: '"dB"'
    gui_hint: 3,1,1,1
  states: {}
- name: check_inputs
  id: snippet
  parameters:
    code: |-
      import os, sys
      if not os.path.exists(self.ts_in):
          sys.exit(
              "\n[Lab 12] Cannot start: the video stream " + self.ts_in + " does not exist.\n"
              "  Make it first (README section 2), from this folder:\n"
              "    ../../03_scripts/make_video_ts.py ~/Downloads/Bintang.mp4 " + self.ts_in + " \\\n"
              "        --mode 16qam-2/3-1/32 --width 1280 --duration 300 --loop\n")
      print("\n[Lab 12] The transmitter starts OFF: TX gain 0, TX amplitude 0.\n"
            "  1. Raise 'TX gain' slowly, then 'TX amplitude' to about 0.5.\n"
            "  2. Watch 'Signal quality' (MER). Above about 15 dB the receiver locks.\n"
            "  3. The video window opens by itself a few seconds after the lock.\n"
            "  Cable and attenuator only - no antennas on a TV channel.\n", flush=True)
    comment: Stops with a clear message if the video stream is missing (instead of "can't open file"), and prints how to bring the transmitter up.
    section: init_before_blocks
  states: {}
- name: window_size
  id: snippet
  parameters:
    code: |-
      if self.width() < 1200:      # GNU Radio does not apply the .grc window size; start usable
          self.resize(1600, 950)
    comment: Opens the window at a usable size the first time.
    section: main_after_init
  states: {}

connections:
- [ts_src, '0', tx_energy, '0']
- [tx_energy, '0', tx_rs, '0']
- [tx_rs, '0', tx_ci, '0']
- [tx_ci, '0', tx_inner, '0']
- [tx_inner, '0', tx_bi, '0']
- [tx_bi, '0', tx_si, '0']
- [tx_si, '0', tx_map, '0']
- [tx_map, '0', tx_pilots, '0']
- [tx_pilots, '0', tx_cp, '0']
- [tx_cp, '0', tx_skip, '0']
- [tx_skip, '0', tx_amp, '0']
- [tx_amp, '0', usrp_tx, '0']
- [usrp_rx, '0', rx_acq, '0']
- [rx_acq, '0', rx_fft, '0']
- [rx_fft, '0', rx_pilots, '0']
- [rx_pilots, '0', rx_demap, '0']
- [rx_demap, '0', rx_si, '0']
- [rx_si, '0', rx_bi, '0']
- [rx_bi, '0', rx_v2s, '0']
- [rx_v2s, '0', rx_viterbi, '0']
- [rx_viterbi, '0', rx_cd, '0']
- [rx_cd, '0', rx_rs, '0']
- [rx_rs, '0', rx_desc, '0']
- [rx_desc, '0', tv_out, '0']
- [rx_pilots, '0', rx_cells, '0']
- [rx_cells, '0', rx_mer, '0']
- [usrp_rx, '0', rx_spectrum, '0']
- [tx_amp, '0', tx_spectrum, '0']
- [rx_cells, '0', rx_const, '0']
- [rx_mer, '0', rx_mer_display, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
