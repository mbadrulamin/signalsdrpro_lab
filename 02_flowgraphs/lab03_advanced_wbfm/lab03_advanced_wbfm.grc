options:
  parameters:
    id: lab03_advanced_wbfm
    title: Lab 03 - Advanced WBFM with AGC, Squelch, Volume (SignalSDR Pro)
    author: SignalSDR Pro Lab
    description: Production-quality FM receiver with filtering, AGC, squelch, volume
    generate_options: qt_gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Front-end rate. 2 MHz of spectrum at 8 bytes/sample = 16 MB/s over USB 3.0.
    value: '2000000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: 'Design the whole chain BACKWARDS from here: 48000 x 8 = 384000, x 125/24 = 2000000.'
    value: '48000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    comment: Rate into the FM demodulator. Must exceed the 180 kHz Carson bandwidth - 384 kHz has room to spare.
    value: '384000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: Hardware tuning. Changing it retunes the AD9361 PLL and briefly interrupts the sample stream.
    label: FM Station (Hz)
    start: 87.5e6
    stop: 108e6
    step: 100e3
    value: 100.0e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: 'See Fundamentals 06 for the procedure: raise until the noise floor moves, then back off 5 dB.'
    label: RF Gain (dB)
    start: '0'
    stop: '76'
    step: '1'
    value: '40'
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    comment: dBFS. Tune to an empty frequency, read the level, then set this about 5 dB above it.
    label: Squelch (dB)
    start: '-80'
    stop: '0'
    step: '1'
    value: '-50'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: Post-demodulation scalar gain. Purely software; nothing here can clip the front end. Starts at 0.5 because a strong station was measured peaking at 1.86 out of the WBFM decoder, and the Audio Sink clips at 1.0.
    label: Volume
    start: '0'
    stop: '5'
    step: '0.1'
    value: '0.5'
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    comment: 'Live IQ from the SignalSDR Pro emulating a USRP B210. Also sets the AD9361 analog filter to samp_rate: without that it defaults to 56 MHz and LO/DC leakage dominates (measured 0.84 of total power vs 0.16).'
    type: fc32
    samp_rate: samp_rate
    sync: none
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    gain0: rf_gain
  states: {}
- name: pre_filter
  id: low_pass_filter
  parameters:
    comment: Channel filter. 53*2e6/(22*20e3) = 241 taps - the tap-count equation from Fundamentals 05.
    type: fir_filter_ccf
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    cutoff_freq: '100000'
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    comment: Placed AFTER the filter so you can see what the demodulator will actually receive.
    type: complex
    name: '"Spectrum"'
    fftsize: '2048'
    fc: freq
    bw: samp_rate
    average: '0.5'
  states: {}
- name: waterfall_sink
  id: qtgui_waterfall_sink_x
  parameters:
    comment: Reveals intermittent signals that an averaged FFT hides.
    type: complex
    name: '"Waterfall"'
    fftsize: '2048'
    fc: freq
    bw: samp_rate
  states: {}
- name: rational_resampler
  id: rational_resampler_xxx
  parameters:
    comment: 2000000 -> 384000 = 24/125 in lowest terms. Polyphase, so the zero-stuffing costs nothing.
    type: ccc
    interp: '24'
    decim: '125'
  states: {}
- name: agc
  id: analog_agc2_xx
  parameters:
    comment: AFTER the channel filter (so a strong neighbour cannot turn our station down) and AFTER the squelch (it lifts noise to the same level as a station, so a squelch placed after it could never close). Attack fast, decay slow.
    type: complex
    reference: '0.5'
    attack_rate: '0.01'
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
  states: {}
- name: dc_blocker
  id: dc_blocker_xx
  parameters:
    type: cc
    length: '128'
    long_form: 'True'
    comment: 'Removes the radio''s own centre spike (DC / LO leakage). Lab 03 tunes straight onto the station, so the spike sits inside the channel. Measured on a SignalSDR Pro at gain 40: the spike alone was -47.6 dB, as strong as BFM 89.9 itself (-47.8 dB), so the squelch could not tell a station (-45.1 dB) from an empty channel (-46.9 dB). Without the spike: -47.8 vs -55.4 dB, and the squelch works.'
  states: {}
- name: squelch
  id: analog_pwr_squelch_xx
  parameters:
    comment: BEFORE the AGC, so it measures the real signal level. gate=False emits zeros when closed; gate=True would emit nothing and starve the audio sink.
    type: complex
    threshold: squelch_threshold
    alpha: '0.01'
    ramp: '0'
    gate: 'False'
  states: {}
- name: wbfm_rcv
  id: analog_wfm_rcv
  parameters:
    comment: 384000/8 = 48000. Quadrature demod, de-emphasis and audio filtering in one block.
    quad_rate: quad_rate
    audio_decimation: '8'
  states: {}
- name: volume_control
  id: blocks_multiply_const_vxx
  parameters:
    comment: Simple scalar multiply on the float audio stream.
    type: float
    const: volume
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    comment: Your speakers. ok_to_block=True lets the sound card set the speed of the whole flowgraph.
    samp_rate: audio_rate
    device_name: '""'
  states: {}

connections:
- [usrp_source, '0', pre_filter, '0']
- [pre_filter, '0', freq_sink, '0']
- [pre_filter, '0', waterfall_sink, '0']
- [pre_filter, '0', rational_resampler, '0']
- [rational_resampler, '0', dc_blocker, '0']
- [dc_blocker, '0', squelch, '0']
- [squelch, '0', agc, '0']
- [agc, '0', wbfm_rcv, '0']
- [wbfm_rcv, '0', volume_control, '0']
- [volume_control, '0', audio_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
