options:
  parameters:
    id: lab03_advanced_wbfm
    title: Lab 03 - Advanced WBFM with AGC, Squelch, Volume (SignalSDR Pro)
    author: SignalSDR Pro Lab
    description: Production-quality FM receiver with filtering, AGC, squelch, volume
    generate_options: qt_gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: FM Station (Hz)
    start: 87.5e6
    stop: 108e6
    step: 100e3
    value: 100.0e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (dB)
    start: '0'
    stop: '76'
    step: '1'
    value: '40'
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    label: Squelch (dB)
    start: '-80'
    stop: '0'
    step: '1'
    value: '-50'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    stop: '5'
    step: '0.1'
    value: '1.0'
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    type: fc32
    samp_rate: samp_rate
    sync: none
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: rf_gain
  states: {}
- name: pre_filter
  id: low_pass_filter
  parameters:
    type: fir_filter_ccf
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    cutoff_freq: '100000'
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Spectrum"'
    fftsize: '2048'
    fc: freq
    bw: samp_rate
    average: '0.5'
  states: {}
- name: waterfall_sink
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: '"Waterfall"'
    fftsize: '2048'
    fc: freq
    bw: samp_rate
  states: {}
- name: rational_resampler
  id: rational_resampler_xxx
  parameters:
    type: ccc
    interp: '24'
    decim: '125'
  states: {}
- name: agc
  id: analog_agc2_xx
  parameters:
    type: complex
    reference: '0.5'
    attack_rate: '0.01'
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
  states: {}
- name: squelch
  id: analog_pwr_squelch_xx
  parameters:
    type: complex
    threshold: squelch_threshold
    alpha: '0.01'
    ramp: '0'
    gate: 'False'
  states: {}
- name: wbfm_rcv
  id: analog_wfm_rcv
  parameters:
    quad_rate: quad_rate
    audio_decimation: '8'
  states: {}
- name: volume_control
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: volume
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: audio_rate
    device_name: '""'
  states: {}

connections:
- [usrp_source, '0', pre_filter, '0']
- [pre_filter, '0', freq_sink, '0']
- [pre_filter, '0', waterfall_sink, '0']
- [pre_filter, '0', rational_resampler, '0']
- [rational_resampler, '0', agc, '0']
- [agc, '0', squelch, '0']
- [squelch, '0', wbfm_rcv, '0']
- [wbfm_rcv, '0', volume_control, '0']
- [volume_control, '0', audio_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
