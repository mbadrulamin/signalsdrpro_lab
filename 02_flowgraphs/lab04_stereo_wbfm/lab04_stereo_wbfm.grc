options:
  parameters:
    id: lab04_stereo_wbfm
    title: Lab 04 - Stereo WBFM with Full MPX Decoding (SignalSDR Pro)
    author: SignalSDR Pro Lab
    description: 'Manual stereo FM decoding: pilot extraction, PLL, L+R/L-R matrix'
    generate_options: qt_gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: USRP sample rate (2 MSPS)
    value: '2000000'
  states: {}
- name: mpx_rate
  id: variable
  parameters:
    comment: Rate after resampler - enough for 100 kHz MPX
    value: '240000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: Final audio sample rate
    value: '48000'
  states: {}
- name: deemph_tau
  id: variable
  parameters:
    comment: 'De-emphasis time constant: 50e-6 (EU) or 75e-6 (US) seconds'
    value: '50e-6'
  states: {}
- name: deemph_alpha
  id: variable
  parameters:
    comment: 'IIR tap: alpha = 1 - exp(-1/(audio_rate*tau))'
    value: 1 - __import__("math").exp(-1/(audio_rate * deemph_tau))
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: Pick a MUSIC station - talk stations are often mono and will show no stereo separation.
    label: FM Station (Hz)
    start: 87.5e6
    stop: 108e6
    step: 100e3
    value: 100.0e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Stereo costs roughly 20 dB of SNR versus mono (Fundamentals 06), so it needs a stronger signal.
    label: RF Gain (dB)
    start: '0'
    stop: '76'
    step: '1'
    value: '40'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: Final audio gain, applied to both channels after the stereo matrix.
    label: Volume
    start: '0'
    stop: '3'
    step: '0.1'
    value: '1.0'
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    comment: 'Live IQ. Everything below is a hand-built receiver - no WBFM Receive block anywhere. Also sets the AD9361 analog filter to samp_rate: without that it defaults to 56 MHz and LO/DC leakage dominates (measured 0.84 of total power vs 0.16).'
    type: fc32
    samp_rate: samp_rate
    sync: none
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    gain0: rf_gain
  states: {}
- name: rf_lowpass
  id: low_pass_filter
  parameters:
    type: fir_filter_ccf
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    cutoff_freq: '100000'
    width: '20000'
    win: window.WIN_HAMMING
    comment: 'Pre-filter: pass only ±100 kHz around tuned freq'
  states: {}
- name: resampler
  id: rational_resampler_xxx
  parameters:
    type: ccc
    interp: '12'
    decim: '100'
    comment: 2 MSPS → 240 kSPS (ratio 12/100)
  states: {}
- name: quad_demod
  id: analog_quadrature_demod_cf
  parameters:
    gain: mpx_rate / (2 * 3.141592653589793 * 75000)
    comment: 'FM demodulator: IQ → MPX baseband (float)'
  states: {}
- name: spectrum_sink
  id: qtgui_freq_sink_x
  parameters:
    comment: 'The MPX baseband: L+R at 0-15 kHz, pilot at 19 kHz, L-R at 23-53 kHz, RDS at 57 kHz.'
    type: float
    name: '"MPX Spectrum"'
    fftsize: '2048'
    fc: '0'
    bw: mpx_rate
    ymin: '-100'
    average: '0.5'
    label1: '"MPX (L+R @ 0-15k, pilot @ 19k, L-R @ 23-53k)"'
  states: {}
- name: lr_plus_lowpass
  id: low_pass_filter
  parameters:
    type: fir_filter_fff
    decim: '5'
    gain: '1'
    samp_rate: mpx_rate
    cutoff_freq: '15000'
    width: '1500'
    win: window.WIN_HAMMING
    comment: Extract L+R mono sum (0–15 kHz)
  states: {}
- name: l_plus_r_deemph
  id: single_pole_iir_filter_xx
  parameters:
    type: float
    alpha: deemph_alpha
    comment: De-emphasis (50/75 us) on L+R
  states: {}
- name: pilot_bandpass
  id: band_pass_filter
  parameters:
    type: fir_filter_fcc
    decim: '1'
    gain: '1'
    samp_rate: mpx_rate
    low_cutoff_freq: '18500'
    high_cutoff_freq: '19500'
    width: '500'
    win: window.WIN_HAMMING
    comment: 'Isolate the 19 kHz pilot (±500 Hz). Float in, COMPLEX out: a complex band-pass keeps only +19 kHz, so the PLL sees one clean tone instead of +19 and -19 kHz together (worth about 12 dB of separation).'
  states: {}
- name: mpx_delay
  id: blocks_delay
  parameters:
    type: float
    delay: (len(firdes.complex_band_pass(1, mpx_rate, 18500, 19500, 500, window.WIN_HAMMING, 6.76)) - 1) // 2
    comment: Delays the MPX by exactly the pilot filter's delay (578 samples), so the rebuilt 38 kHz carrier lines up with the L-R signal it demodulates. Without it the carrier phase is effectively random and stereo collapses to mono.
  states: {}
- name: pilot_pll
  id: analog_pll_refout_cc
  parameters:
    w: '0.05'
    min_freq: 2 * 3.141592653589793 * 18500 / mpx_rate
    max_freq: 2 * 3.141592653589793 * 19500 / mpx_rate
    comment: PLL locks to the 19 kHz pilot and outputs a clean complex tone with the same phase.
  states: {}
- name: subcarrier_doubler
  id: blocks_multiply_xx
  parameters:
    type: complex
    comment: 19 kHz × 19 kHz = 38 kHz (double the frequency)
  states: {}
- name: subcarrier_to_imag
  id: blocks_complex_to_imag
  parameters:
    comment: Broadcast stereo uses a SINE pilot and a SINE 38 kHz carrier. Squaring the PLL output of sin(wt) gives -cos(2wt) - j*sin(2wt), so the carrier we need is minus the IMAGINARY part (the minus sign is applied in scale_lr_minus).
  states: {}
- name: lrmix
  id: blocks_multiply_xx
  parameters:
    type: float
    comment: Delayed MPX x sin(2*pi*38k*t) moves L-R from 38 kHz down to audio.
  states: {}
- name: lr_minus_lowpass
  id: low_pass_filter
  parameters:
    type: fir_filter_fff
    decim: '5'
    gain: '1'
    samp_rate: mpx_rate
    cutoff_freq: '15000'
    width: '1500'
    win: window.WIN_HAMMING
    comment: Extract L-R difference (0–15 kHz)
  states: {}
- name: scale_lr_minus
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '-2.0'
    comment: x2 because DSB-SC demodulation halves the amplitude; the minus sign completes -Imag = +sin(2wt).
  states: {}
- name: l_minus_r_deemph
  id: single_pole_iir_filter_xx
  parameters:
    type: float
    alpha: deemph_alpha
    comment: De-emphasis (50/75 us) on L-R
  states: {}
- name: left_add
  id: blocks_add_xx
  parameters:
    type: float
    comment: L = (L+R) + (L-R)
  states: {}
- name: right_subtract
  id: blocks_sub_xx
  parameters:
    type: float
    comment: R = (L+R) - (L-R)
  states: {}
- name: scale_left
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: volume * 0.5
    comment: Scale to 50% (matrix doubled) + apply volume
  states: {}
- name: scale_right
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'The 0.5 undoes the factor of 2 the stereo matrix introduces: (L+R)-(L-R) = 2R.'
    type: float
    const: volume * 0.5
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: audio_rate
    num_inputs: '2'
    device_name: '""'
    comment: 'Stereo output: L and R channels'
  states: {}

connections:
- [usrp_source, '0', rf_lowpass, '0']
- [rf_lowpass, '0', resampler, '0']
- [resampler, '0', quad_demod, '0']
- [quad_demod, '0', spectrum_sink, '0']
- [quad_demod, '0', mpx_delay, '0']
- [mpx_delay, '0', lr_plus_lowpass, '0']
- [lr_plus_lowpass, '0', l_plus_r_deemph, '0']
- [quad_demod, '0', pilot_bandpass, '0']
- [pilot_bandpass, '0', pilot_pll, '0']
- [pilot_pll, '0', subcarrier_doubler, '0']
- [pilot_pll, '0', subcarrier_doubler, '1']
- [subcarrier_doubler, '0', subcarrier_to_imag, '0']
- [mpx_delay, '0', lrmix, '0']
- [subcarrier_to_imag, '0', lrmix, '1']
- [lrmix, '0', lr_minus_lowpass, '0']
- [lr_minus_lowpass, '0', scale_lr_minus, '0']
- [scale_lr_minus, '0', l_minus_r_deemph, '0']
- [l_plus_r_deemph, '0', left_add, '0']
- [l_minus_r_deemph, '0', left_add, '1']
- [l_plus_r_deemph, '0', right_subtract, '0']
- [l_minus_r_deemph, '0', right_subtract, '1']
- [left_add, '0', scale_left, '0']
- [right_subtract, '0', scale_right, '0']
- [scale_left, '0', audio_sink, '0']
- [scale_right, '0', audio_sink, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
