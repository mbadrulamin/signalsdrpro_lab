options:
  parameters:
    id: lab06_multimode_receiver
    title: 'Lab 06 - Multimode Receiver: AM / NBFM / WBFM with Channel Selection'
    author: SignalSDR Pro Lab
    description: One tuner, three demodulators, software channel selection, S-meter and squelch
    generate_options: qt_gui
  states: {}

blocks:
- name: note_legal
  id: note
  parameters:
    comment: Receive only. Check your local regulations.
    note: Airband 118-137 AM | Marine 156-162 NBFM (ch16 = 156.800) | Amateur 2 m 144-148 NBFM | Broadcast 87.5-108 WBFM
  states: {}
- name: note_offset
  id: note
  parameters:
    comment: Why we never tune directly onto the signal
    note: Tune freq ~200 kHz AWAY from your target and use offset_freq to reach it - this dodges the LO/DC spike.
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Front-end rate. 2 MHz of spectrum captured at once - the pool we select channels from.
    value: '2000000'
  states: {}
- name: wide_rate
  id: variable
  parameters:
    comment: 2000000/5 = 400000. Wide enough for a whole 200 kHz WBFM channel.
    value: int(samp_rate/5)
  states: {}
- name: narrow_rate
  id: variable
  parameters:
    comment: 400000/8 = 50000. Plenty for AM (8 kHz) and NBFM (16 kHz) channels.
    value: int(wide_rate/8)
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: All three demodulator branches deliberately produce the SAME audio rate so the Selector can switch between them.
    value: '50000'
  states: {}
- name: wide_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: N = 53*2e6/(22*30e3) = 161 taps. Anti-alias for the decimate-by-5 inside the xlating filter.
    gain: '1.0'
    samp_rate: samp_rate
    cutoff_freq: 150e3
    width: 30e3
    win: window.WIN_HAMMING
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: HARDWARE tuning. Changing this retunes the AD9361 PLL and briefly interrupts the stream.
    label: Hardware Centre (Hz)
    start: 70e6
    stop: 6000e6
    step: 100e3
    value: 100.1e6
    min_len: '400'
  states: {}
- name: offset_freq
  id: variable_qtgui_range
  parameters:
    comment: SOFTWARE tuning inside the captured 2 MHz. Instant, no PLL settling, no gap in the stream.
    label: Channel Offset (Hz)
    start: '-900e3'
    stop: 900e3
    step: 5e3
    value: '-200e3'
    min_len: '400'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: 'See Fundamentals 06: raise until the noise floor starts rising with it, then back off 5 dB.'
    label: RF Gain (dB)
    start: '0'
    stop: '76'
    step: '1'
    value: '40'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    comment: Drives the Selector index. All three demodulators always run; this picks which one you hear.
    label: Demodulator
    type: int
    num_opts: '3'
    option0: '0'
    label0: AM (airband, shortwave)
    option1: '1'
    label1: NBFM (marine, weather, PMR)
    option2: '2'
    label2: WBFM (broadcast 88-108)
    value: '2'
    widget: radio_buttons
    orient: Qt.QHBoxLayout
  states: {}
- name: narrow_bw
  id: variable_qtgui_range
  parameters:
    comment: Channel filter cutoff for the narrowband path. AM airband ~4 kHz, NBFM ~8 kHz. Ignored in WBFM mode.
    label: Narrow Channel BW (Hz)
    start: '3000'
    stop: '18000'
    step: '500'
    value: '8000'
    min_len: '250'
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    comment: Set ~5 dB above the S-meter reading on an empty channel.
    label: Squelch (dBFS)
    start: '-90'
    stop: '0'
    step: '1'
    value: '-70'
    min_len: '250'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: Final audio scaling, after the Selector.
    label: Volume
    start: '0'
    stop: '5'
    step: '0.1'
    value: '1.0'
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    comment: One tuner. Everything below this line is software - that is the whole point of the lab.
    type: fc32
    dev_args: '""'
    samp_rate: samp_rate
    sync: none
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    gain0: rf_gain
  states: {}
- name: wide_sink
  id: qtgui_freq_sink_x
  parameters:
    comment: The full 2 MHz pool. Find your signal here, read off its offset, dial it into offset_freq.
    type: complex
    name: '"Full Span - pick a channel here"'
    fftsize: '4096'
    fc: freq
    bw: samp_rate
    average: '0.2'
    grid: 'True'
    gui_hint: 0,0,1,2
  states: {}
- name: waterfall_sink
  id: qtgui_waterfall_sink_x
  parameters:
    comment: Bursty traffic (airband, marine) is far easier to see here than on the FFT.
    type: complex
    name: '"Full Span Waterfall"'
    fftsize: '4096'
    fc: freq
    bw: samp_rate
    gui_hint: 1,0,1,2
  states: {}
- name: xlating_wide
  id: freq_xlating_fir_filter_xxx
  parameters:
    comment: 'THE channel selector: mix by -offset_freq, low-pass 150 kHz, decimate by 5. 2 MSPS -> 400 kSPS.'
    type: ccf
    decim: '5'
    taps: wide_taps
    center_freq: offset_freq
    samp_rate: samp_rate
  states: {}
- name: agc_wide
  id: analog_agc2_xx
  parameters:
    comment: AGC AFTER the channel filter - so a strong neighbour cannot turn our station down. See Fundamentals 06.
    type: complex
    reference: '0.5'
    attack_rate: '0.01'
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '4096'
  states: {}
- name: wbfm_rcv
  id: analog_wfm_rcv
  parameters:
    comment: 'WBFM branch: 400000/8 = 50000 audio. Quadrature demod + de-emphasis, all in one block.'
    quad_rate: wide_rate
    audio_decimation: '8'
  states: {}
- name: narrow_lpf
  id: low_pass_filter
  parameters:
    comment: Second-stage channel filter. 481 taps, but running at only 50 kSPS output - cheap. 400 kSPS -> 50 kSPS.
    type: fir_filter_ccf
    decim: '8'
    gain: '1'
    samp_rate: wide_rate
    cutoff_freq: narrow_bw
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: chan_sink
  id: qtgui_freq_sink_x
  parameters:
    comment: The selected narrow channel, centred at DC. Your signal should sit exactly in the middle.
    type: complex
    name: '"Selected Narrow Channel"'
    fftsize: '1024'
    fc: '0'
    bw: narrow_rate
    average: '0.2'
    grid: 'True'
    gui_hint: 2,0,1,1
  states: {}
- name: squelch
  id: analog_pwr_squelch_xx
  parameters:
    comment: gate=False emits ZEROS when closed. gate=True would emit nothing and starve the audio sink.
    type: complex
    threshold: squelch_threshold
    alpha: '0.01'
    ramp: '20'
    gate: 'False'
  states: {}
- name: agc_narrow
  id: analog_agc2_xx
  parameters:
    comment: 'Holds the AM carrier at exactly 1.0. That matters: AM Demod subtracts a fixed 1.0 after taking the envelope, so any other reference leaves a DC offset on the audio (0.3 gave -0.35, and a pop on every mode change). NBFM ignores the level.'
    type: complex
    reference: '1.0'
    attack_rate: '0.02'
    decay_rate: '0.0005'
    gain: '1.0'
    max_gain: '4096'
  states: {}
- name: am_demod
  id: analog_am_demod_cf
  parameters:
    comment: 'AM branch: envelope detection |I+jQ| plus a 5 kHz audio low-pass. Immune to tuning offset.'
    chan_rate: narrow_rate
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
  states: {}
- name: nbfm_rcv
  id: analog_nbfm_rx
  parameters:
    comment: 'NBFM branch: quad demod with max_dev 5 kHz + de-emphasis. audio_rate == quad_rate, so decimation is 1.'
    audio_rate: audio_rate
    quad_rate: narrow_rate
    tau: '75e-6'
    max_dev: 5e3
  states: {}
- name: mode_selector
  id: blocks_selector
  parameters:
    comment: Runtime switch. Input 0=AM, 1=NBFM, 2=WBFM. All branches keep running; only one is forwarded.
    type: float
    enabled: 'True'
    num_inputs: '3'
    num_outputs: '1'
    input_index: mode
    output_index: '0'
  states: {}
- name: volume_control
  id: blocks_multiply_const_vxx
  parameters:
    comment: Scalar audio gain.
    type: float
    const: volume
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    comment: 50 kHz mono. Every demodulator branch was designed to land exactly here.
    samp_rate: audio_rate
    device_name: '""'
  states: {}
- name: audio_time_sink
  id: qtgui_time_sink_x
  parameters:
    comment: Watch the squelch open and close, and check for clipping.
    type: float
    name: '"Demodulated Audio"'
    size: '2048'
    srate: audio_rate
    ymin: '-1.5'
    ymax: '1.5'
    grid: 'True'
    gui_hint: 2,1,1,1
  states: {}
- name: smeter_mag
  id: blocks_complex_to_mag_squared
  parameters:
    comment: S-meter tap, taken AFTER the channel filter so it measures THIS channel, not the whole band.
  states: {}
- name: smeter_avg
  id: blocks_moving_average_xx
  parameters:
    comment: 5000 samples = 100 ms at 50 kSPS. Fast enough to follow speech, slow enough to read.
    type: float
    length: '5000'
    scale: 1.0/5000
    max_iter: '5000'
  states: {}
- name: smeter_db
  id: blocks_nlog10_ff
  parameters:
    comment: 10*log10(2*P) = dBFS. Use this number to choose the squelch threshold.
    n: '10'
    k: '3.0103'
  states: {}
- name: smeter_sink
  id: qtgui_number_sink
  parameters:
    comment: Channel power. Empty channel gives you the noise floor; set squelch ~5 dB above it.
    name: '"Channel S-Meter"'
    type: float
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '-100'
    max: '0'
    label1: '"Channel Power"'
    unit1: '"dBFS"'
    gui_hint: 3,0,1,2
  states: {}

connections:
- [usrp_source, '0', xlating_wide, '0']
- [usrp_source, '0', wide_sink, '0']
- [usrp_source, '0', waterfall_sink, '0']
- [xlating_wide, '0', agc_wide, '0']
- [xlating_wide, '0', narrow_lpf, '0']
- [agc_wide, '0', wbfm_rcv, '0']
- [narrow_lpf, '0', squelch, '0']
- [narrow_lpf, '0', chan_sink, '0']
- [narrow_lpf, '0', smeter_mag, '0']
- [squelch, '0', agc_narrow, '0']
- [agc_narrow, '0', am_demod, '0']
- [agc_narrow, '0', nbfm_rcv, '0']
- [am_demod, '0', mode_selector, '0']
- [nbfm_rcv, '0', mode_selector, '1']
- [wbfm_rcv, '0', mode_selector, '2']
- [mode_selector, '0', volume_control, '0']
- [volume_control, '0', audio_sink, '0']
- [volume_control, '0', audio_time_sink, '0']
- [smeter_mag, '0', smeter_avg, '0']
- [smeter_avg, '0', smeter_db, '0']
- [smeter_db, '0', smeter_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
